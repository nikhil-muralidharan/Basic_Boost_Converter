v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {powern.sym} 310 50 0 0 {name=X1}
C {powerp.sym} 230 40 0 0 {name=X2}
