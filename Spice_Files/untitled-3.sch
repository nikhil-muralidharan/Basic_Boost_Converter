v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {powerp.sym} 1360 -1100 0 0 {name=X1}
