v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {powerpsym} -30 60 0 0 {name=X1}
