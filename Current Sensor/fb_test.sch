v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 330 -290 390 -290 {
lab=ZCD}
N 360 -330 360 -290 {
lab=ZCD}
N 390 -450 390 -350 {
lab=Vin}
N 390 -450 445 -450 {
lab=Vin}
N 580 -320 640 -320 {
lab=Vin_Div}
N 580 -290 640 -290 {
lab=Csense}
N 580 -260 640 -260 {
lab=Ttrig}
N 330 -220 350 -220 {
lab=ZCDB}
N 350 -220 350 -190 {
lab=ZCDB}
N 350 -190 380 -190 {
lab=ZCDB}
N 250 -540 250 -320 {
lab=#net1}
N 250 -540 380 -540 {
lab=#net1}
N 380 -540 490 -540 {
lab=#net1}
N 490 -540 490 -350 {
lab=#net1}
N 380 -540 380 -535 {
lab=#net1}
N 80 -180 170 -180 {
lab=Ndrive_Final}
N 360 -260 390 -260 {
lab=#net2}
N 360 -200 360 -170 {
lab=GND}
N 360 -170 390 -170 {
lab=GND}
N 90 -440 250 -440 {
lab=#net1}
N 135 -400 342.5 -400 {
lab=PDRIVEB}
N 342.5 -400 342.5 -317.5 {
lab=PDRIVEB}
N 342.5 -317.5 382.5 -317.5 {
lab=PDRIVEB}
N 382.5 -318.75 382.5 -317.5 {
lab=PDRIVEB}
N 382.5 -320 390 -320 {
lab=PDRIVEB}
N 382.5 -320 382.5 -318.75 {
lab=PDRIVEB}
N 283.75 -440 283.75 -400 {
lab=PDRIVEB}
N 285 -843.75 375 -843.75 { lab=Vout}
N -15 -843.75 85 -843.75 { lab=VLX}
N 165 -843.75 285 -843.75 { lab=Vout}
N -15 -583.75 -15 -553.75 { lab=GND}
N -90 -633.75 -50 -633.75 { lab=Ndrive_Final}
N -220 -716.25 -220 -250 {
lab=Vout}
N -220 -250 162.5 -250 {
lab=Vout}
N 162.5 -250 170 -250 {
lab=Vout}
N -165 -843.75 -75 -843.75 {
lab=Vin}
N -180 -633.75 -90 -633.75 {
lab=Ndrive_Final}
N 50 -900 50 -400 {
lab=Pdrive_final}
N 50 -900 123.75 -900 {
lab=Pdrive_final}
N 123.75 -900 125 -900 {
lab=Pdrive_final}
N 125 -900 125 -883.75 {
lab=Pdrive_final}
N -221.25 -716.25 441.25 -716.25 {
lab=Vout}
N 441.25 -782.5 441.25 -716.25 {
lab=Vout}
N 441.25 -783.75 441.25 -782.5 {
lab=Vout}
N -15 -843.75 -15 -683.75 {
lab=VLX}
N -15 -696.25 138.75 -696.25 {
lab=VLX}
N 137.5 -320 138.75 -696.25 {
lab=VLX}
N 137.5 -320 170 -320 {
lab=VLX}
N -105 -736.25 -15 -736.25 {
lab=VLX}
N -40 -500 50 -500 {
lab=Pdrive_final}
N 100 -290 100 -180 {
lab=Ndrive_Final}
N -160 -290 100 -290 {
lab=Ndrive_Final}
N -160 -632.5 -160 -290 {
lab=Ndrive_Final}
N -160 -633.75 -160 -632.5 {
lab=Ndrive_Final}
N 441.25 -783.75 501.25 -783.75 {
lab=Vout}
N 375 -843.75 426.25 -843.75 {
lab=Vout}
N 426.25 -843.75 463.75 -843.75 {
lab=Vout}
N 520 -200 580 -200 {
lab=C1}
N 460 -160 520 -160 {
lab=CC}
N 520 -230 520 -200 {
lab=C1}
N 460 -230 460 -160 {
lab=CC}
N 440.625 -783.75 441.25 -783.75 {
lab=Vout}
N 230 -60 290 -60 {
lab=S}
N 230 -130 230 -60 {
lab=S}
N 230 -180 230 -130 {
lab=S}
N 280 -110 340 -110 {
lab=R}
N 280 -180 280 -110 {
lab=R}
N 455 -843.75 455 -783.75 {
lab=Vout}
N 440 -450 930 -450 {
lab=Vin}
N 930 -950 930 -450 {
lab=Vin}
N -120 -950 930 -950 {
lab=Vin}
N -120 -950 -120 -850 {
lab=Vin}
N -120 -850 -120 -843.75 {
lab=Vin}
N -380 -380 -320 -380 {
lab=Vsen}
N -380 -260 -320 -260 {
lab=Vsendc}
N -600 -450 50 -450 {
lab=Pdrive_final}
N -600 -450 -600 -320 {
lab=Pdrive_final}
N -600 -320 -540 -320 {
lab=Pdrive_final}
N -475 -440 90 -440 {
lab=#net1}
N -475 -440 -475 -380 {
lab=#net1}
N -540 -780 -540 -380 {
lab=VLX}
N -540 -780 -110 -780 {
lab=VLX}
N -110 -780 -110 -760 {
lab=VLX}
N -110 -760 -15 -760 {
lab=VLX}
N 635 -260 635 315 {
lab=Ttrig}
N 635 315 715 315 {
lab=Ttrig}
N 345 -290 345 285 {
lab=ZCD}
N 345 285 715 285 {
lab=ZCD}
N 205 -400 205 175 {
lab=PDRIVEB}
N 205 175 205 250 {
lab=PDRIVEB}
N 205 250 685 250 {
lab=PDRIVEB}
N 685 250 685 255 {
lab=PDRIVEB}
N 685 255 715 255 {
lab=PDRIVEB}
N -345 -260 -345 50 {
lab=Vsendc}
N -345 50 570 50 {
lab=Vsendc}
N 570 50 570 100 {
lab=Vsendc}
N 570 100 685 100 {
lab=Vsendc}
N 685 100 685 105 {
lab=Vsendc}
N 685 105 715 105 {
lab=Vsendc}
N -330 -380 -330 30 {
lab=Vsen}
N -330 30 620 30 {
lab=Vsen}
N 620 30 620 65 {
lab=Vsen}
N 620 65 715 65 {
lab=Vsen}
N 490 -380 860 -380 {
lab=#net1}
N 860 -380 860 5 {
lab=#net1}
N 860 5 875 5 {
lab=#net1}
N 875 5 875 25 {
lab=#net1}
N 1005 125 1065 125 {
lab=Vout_compare}
N 1005 155 1065 155 {
lab=CLK}
N 1005 185 1065 185 {
lab=CLKb}
N 690 25 715 25 {
lab=#net3}
N 375 -783.75 421.25 -783.75 {
lab=#net4}
N 421.25 -783.75 421.25 143.75 {
lab=#net4}
N 421.25 143.75 706.25 143.75 {
lab=#net4}
N 706.25 143.75 706.25 146.25 {
lab=#net4}
N 706.25 146.25 708.75 146.25 {
lab=#net4}
N 708.75 145 708.75 146.25 {
lab=#net4}
N 708.75 145 715 145 {
lab=#net4}
N 582.5 202.5 701.25 202.5 {
lab=#net5}
N 701.25 185 701.25 202.5 {
lab=#net5}
N 701.25 185 715 185 {
lab=#net5}
N 701.25 202.5 701.25 225 {
lab=#net5}
N 701.25 225 715 225 {
lab=#net5}
N 1046.25 155 1046.25 168.75 {
lab=CLK}
N 1046.25 168.75 1160 168.75 {
lab=CLK}
N 1160 168.75 1228.75 168.75 {
lab=CLK}
N 1228.75 168.75 1245 168.75 {
lab=CLK}
N 1385 118.75 1445 118.75 {
lab=Pdrive1}
N 1385 138.75 1445 138.75 {
lab=Ndrive1}
N 1385 158.75 1445 158.75 {
lab=Pctrl}
N 1385 178.75 1445 178.75 {
lab=Nctrl}
N 1385 198.75 1445 198.75 {
lab=Vout_mux}
N 875 10 1313.75 10 {
lab=#net1}
N 1313.75 10 1313.75 100 {
lab=#net1}
N 1315 95 1315 108.75 {
lab=#net1}
N 1313.75 95 1315 95 {
lab=#net1}
N 486.25 285 486.25 397.5 {
lab=ZCD}
N 486.25 397.5 1140 397.5 {
lab=ZCD}
N 1138.75 187.5 1138.75 397.5 {
lab=ZCD}
N 1138.75 187.5 1230 187.5 {
lab=ZCD}
N 1230 187.5 1230 190 {
lab=ZCD}
N 1230 190 1236.25 190 {
lab=ZCD}
N 1236.25 188.75 1236.25 190 {
lab=ZCD}
N 1236.25 188.75 1245 188.75 {
lab=ZCD}
N -15 -747.5 1098.75 -747.5 {
lab=VLX}
N 1098.75 -747.5 1098.75 81.25 {
lab=VLX}
N 1098.75 81.25 1221.25 81.25 {
lab=VLX}
N 1221.25 81.25 1221.25 128.75 {
lab=VLX}
N 1221.25 128.75 1245 128.75 {
lab=VLX}
N 1960 -250 1960 -110 {
lab=Pdrive1}
N 2020 -250 2020 -110 {
lab=Pdrive_final}
N 1990 -130 1990 -110 {
lab=Pdrive_final}
N 2070 -130 2070 -70 {
lab=GND}
N 1990 -250 1990 -220 {
lab=Pdrive_final}
N 1960 -500 1960 -360 {
lab=Pdrive}
N 2020 -500 2020 -360 {
lab=Pdrive_final}
N 1990 -380 1990 -360 {
lab=Pdrive_final}
N 2070 -380 2070 -320 {
lab=GND}
N 1990 -500 1990 -470 {
lab=Pdrive_final}
N 1900 -470 1900 -220 {
lab=#net6}
N 2070 -320 2070 -130 {
lab=GND}
N 2020 -430 2250 -430 {
lab=Pdrive_final}
N 2020 -180 2250 -180 {
lab=Pdrive_final}
N 2250 -430 2250 -180 {
lab=Pdrive_final}
N 1990 -540 2290 -540 {
lab=#net7}
N 2290 -540 2290 -80 {
lab=#net7}
N 2030 -80 2290 -80 {
lab=#net7}
N 2030 -80 2030 -70 {
lab=#net7}
N 1990 -70 2030 -70 {
lab=#net7}
N 2290 -450 2400 -450 {
lab=#net7}
N 1805 -300 1990 -300 {
lab=#net8}
N 1990 -320 1990 -300 {
lab=#net8}
N 1990 -320 1990 -290 {
lab=#net8}
N 1760 -440 1900 -440 {
lab=#net6}
N 1760 -440 1760 -340 {
lab=#net6}
N 1640 -70 1990 -70 {
lab=#net7}
N 1640 -300 1640 -70 {
lab=#net7}
N 1640 -300 1720 -300 {
lab=#net7}
N 1620 -430 1960 -430 {
lab=Pdrive}
N 1600 -180 1960 -180 {
lab=Pdrive1}
N 1430 -180 1430 120 {
lab=Pdrive1}
N 1430 -180 1600 -180 {
lab=Pdrive1}
N 1410 110 1430 110 {
lab=Pdrive1}
N 1410 110 1410 117.5 {
lab=Pdrive1}
N 1410 117.5 1410 118.75 {
lab=Pdrive1}
N 2328.75 -627.5 2328.75 -298.75 {
lab=Pdrive_final}
N 50 -628.75 2328.75 -627.5 {
lab=Pdrive_final}
N 1661.25 -481.25 1721.25 -481.25 {
lab=Pdrive}
N 1661.25 -481.25 1661.25 -430 {
lab=Pdrive}
N 1876.25 -388.75 1900 -388.75 {
lab=#net6}
N 1972.5 432.5 1972.5 572.5 {
lab=Ndrive1}
N 2032.5 432.5 2032.5 572.5 {
lab=Ndrive_Final}
N 2002.5 552.5 2002.5 572.5 {
lab=Ndrive_Final}
N 2082.5 552.5 2082.5 612.5 {
lab=GND}
N 2002.5 432.5 2002.5 462.5 {
lab=Ndrive_Final}
N 1972.5 182.5 1972.5 322.5 {
lab=Ndrive}
N 2032.5 182.5 2032.5 322.5 {
lab=Ndrive_Final}
N 2002.5 302.5 2002.5 322.5 {
lab=Ndrive_Final}
N 2082.5 302.5 2082.5 362.5 {
lab=GND}
N 2002.5 182.5 2002.5 212.5 {
lab=Ndrive_Final}
N 1912.5 212.5 1912.5 462.5 {
lab=#net9}
N 2082.5 362.5 2082.5 552.5 {
lab=GND}
N 2032.5 252.5 2262.5 252.5 {
lab=Ndrive_Final}
N 2032.5 502.5 2262.5 502.5 {
lab=Ndrive_Final}
N 2262.5 252.5 2262.5 502.5 {
lab=Ndrive_Final}
N 2262.5 382.5 2342.5 382.5 {
lab=Ndrive_Final}
N 2002.5 142.5 2302.5 142.5 {
lab=#net7}
N 2302.5 142.5 2302.5 602.5 {
lab=#net7}
N 2042.5 602.5 2302.5 602.5 {
lab=#net7}
N 2042.5 602.5 2042.5 612.5 {
lab=#net7}
N 2002.5 612.5 2042.5 612.5 {
lab=#net7}
N 2302.5 232.5 2412.5 232.5 {
lab=#net7}
N 1817.5 382.5 2002.5 382.5 {
lab=#net10}
N 2002.5 362.5 2002.5 382.5 {
lab=#net10}
N 2002.5 362.5 2002.5 392.5 {
lab=#net10}
N 1772.5 242.5 1912.5 242.5 {
lab=#net9}
N 1772.5 242.5 1772.5 342.5 {
lab=#net9}
N 1652.5 612.5 2002.5 612.5 {
lab=#net7}
N 1652.5 382.5 1652.5 612.5 {
lab=#net7}
N 1652.5 382.5 1732.5 382.5 {
lab=#net7}
N 1632.5 252.5 1972.5 252.5 {
lab=Ndrive}
N 1612.5 502.5 1972.5 502.5 {
lab=Ndrive1}
N 1673.75 201.25 1733.75 201.25 {
lab=Ndrive}
N 1673.75 201.25 1673.75 252.5 {
lab=Ndrive}
N 1888.75 293.75 1912.5 293.75 {
lab=#net9}
N 1427.5 138.75 1427.5 500 {
lab=Ndrive1}
N 1427.5 500 1590 500 {
lab=Ndrive1}
N 1590 500 1590 502.5 {
lab=Ndrive1}
N 1590 502.5 1613.75 502.5 {
lab=Ndrive1}
N -117.5 816.25 2338.75 818.75 {
lab=Ndrive_Final}
N -117.5 -110 -117.5 816.25 {
lab=Ndrive_Final}
N -117.5 -110 130 -110 {
lab=Ndrive_Final}
N 130 -180 130 -110 {
lab=Ndrive_Final}
N 2338.75 387.5 2338.75 818.75 {
lab=Ndrive_Final}
N 2338.75 382.5 2338.75 387.5 {
lab=Ndrive_Final}
N 2250 -297.5 2327.5 -297.5 {
lab=Pdrive_final}
N 2327.5 -297.5 2328.75 -297.5 {
lab=Pdrive_final}
N 2328.75 -298.75 2328.75 -297.5 {
lab=Pdrive_final}
N 2397.5 -450 2397.5 206.25 {
lab=#net7}
N 2397.5 206.25 2397.5 232.5 {
lab=#net7}
N 1990 -470 2020 -470 {
lab=Pdrive_final}
N 1990 -380 2020 -380 {
lab=Pdrive_final}
N 1990 -220 2020 -220 {
lab=Pdrive_final}
N 1990 -130 2020 -130 {
lab=Pdrive_final}
N 2002.5 212.5 2032.5 212.5 {
lab=Ndrive_Final}
N 2002.5 302.5 2032.5 302.5 {
lab=Ndrive_Final}
N 2002.5 552.5 2032.5 552.5 {
lab=Ndrive_Final}
N 2002.5 462.5 2032.5 462.5 {
lab=Ndrive_Final}
C {otg.sym} 390 -350 0 0 {name=X1}
C {zcd.sym} 9140 520 0 0 {name=X2}
C {devices/opin.sym} 360 -330 3 0 {name=p1 lab=ZCD}
C {devices/opin.sym} 640 -320 0 0 {name=p2 lab=Vin_Div}
C {devices/opin.sym} 640 -290 0 0 {name=p3 lab=Csense}
C {devices/opin.sym} 640 -260 0 0 {name=p4 lab=Ttrig}
C {devices/opin.sym} 380 -190 0 0 {name=p5 lab=ZCDB}
C {devices/vsource.sym} 380 -505 0 0 {name=VDD value=1.8}
C {devices/gnd.sym} 380 -475 0 0 {name=l2 lab=GND}
C {devices/vsource.sym} 1632.5 282.5 0 0 {name=V2 value= "PULSE (0 1.8 0 0.01us 0.01us 0.875us 1.25us)"}
C {devices/gnd.sym} 1632.5 312.5 0 0 {name=l3 lab=GND}
C {devices/opin.sym} 80 -180 2 0 {name=p6 lab=Ndrive_Final}
C {devices/vsource.sym} 390 -200 0 0 {name=V_Comparator_bias value=0.5}
C {devices/vsource.sym} 360 -230 0 0 {name=V_ref value=0.8}
C {devices/gnd.sym} 390 -170 0 0 {name=l4 lab=GND}
C {inverter.sym} -10 -400 0 0 {name=X3}
C {devices/vsource.sym} 1620 -400 0 0 {name=V4 value= "PULSE (0 1.8 0 0.01us 0.01us 0.375us 1.25us)"}
C {devices/gnd.sym} 1620 -370 0 0 {name=l5 lab=GND}
C {devices/opin.sym} 283.75 -440 3 0 {name=p7 lab=PDRIVEB}
C {devices/code.sym} -378.75 -593.75 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt_mm

"
spice_ignore=false}
C {devices/capa.sym} 285 -813.75 0 0 {name=C1
m=1
value=4.375u
footprint=1206
device="ceramic capacitor"}
C {devices/res.sym} 375 -813.75 0 0 {name=R1
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} -15 -553.75 0 0 {name=l6 lab=GND}
C {devices/ind.sym} -45 -843.75 3 0 {name=L1
m=1
value=3.125u
footprint=1206
device=inductor}
C {devices/gnd.sym} -75 -783.75 0 0 {name=l10 lab=GND}
C {powern.sym} -390 -633.75 0 0 {name=X4}
C {powerp.sym} 125 -1003.75 3 1 {name=X5}
C {devices/res.sym} 375 -753.75 2 0 {name=R2
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 285 -783.75 0 0 {name=l7 lab=GND}
C {devices/gnd.sym} 375 -723.75 0 0 {name=l8 lab=GND}
C {devices/opin.sym} -165 -843.75 2 0 {name=p8 lab=Vin}
C {devices/opin.sym} -105 -736.25 2 0 {name=p10 lab=VLX}
C {devices/opin.sym} -40 -500 2 0 {name=p11 lab=Pdrive_final}
C {devices/opin.sym} 501.25 -783.75 0 0 {name=p9 lab=Vout}
C {devices/opin.sym} 580 -200 0 0 {name=p12 lab=C1}
C {devices/opin.sym} 520 -160 0 0 {name=p13 lab=CC}
C {devices/opin.sym} 290 -60 0 0 {name=p14 lab=S}
C {devices/opin.sym} 340 -110 0 0 {name=p15 lab=R}
C {Current_Sensor.sym} -1300 1980 0 0 {name=X7}
C {devices/opin.sym} -320 -380 0 0 {name=p18 lab=Vsen}
C {devices/opin.sym} -320 -260 0 0 {name=p19 lab=Vsendc}
C {devices/vsource.sym} -440 -350 0 0 {name=V_Comparator_bias1 value=0.5}
C {devices/gnd.sym} -440 -320 0 0 {name=l1 lab=GND}
C {devices/code_shown.sym} 1180 -927.5 0 0 {name=SPICE only_toplevel=false value="
.param Vhigh=1.8
.param Vlow=0
.tran 0.1ms 0.35ms 0ms 0.1ms uic"
}
C {devices/vsource.sym} -75 -813.75 0 0 {name=V1 value="pwl 0 1 0.1ms 1 0.101ms 0.8 0.15ms 0.8 0.151ms 1 0.2ms 1 0.3ms 1 0.301ms 1.2 0.35ms 1.2 0.351ms 1 0.4ms 1"}
C {mroat.sym} 1275 635 0 0 {name=X6}
C {devices/opin.sym} 1065 125 0 0 {name=p16 lab=Vout_compare}
C {devices/opin.sym} 1065 155 0 0 {name=p17 lab=CLK}
C {devices/opin.sym} 1065 185 0 0 {name=p20 lab=CLKb}
C {devices/vsource.sym} 690 55 0 0 {name=V_ref1 value=0.8}
C {devices/gnd.sym} 690 85 0 0 {name=l19 lab=GND}
C {devices/vsource.sym} 582.5 232.5 0 0 {name=VCB2 value=0.5}
C {devices/gnd.sym} 582.5 262.5 0 0 {name=l9 lab=GND}
C {dtc.sym} 1185 268.75 0 0 {name=X8}
C {devices/opin.sym} 1445 118.75 0 0 {name=p21 lab=Pdrive1}
C {devices/opin.sym} 1445 138.75 0 0 {name=p22 lab=Ndrive1}
C {devices/opin.sym} 1445 158.75 0 0 {name=p23 lab=Pctrl}
C {devices/opin.sym} 1445 178.75 0 0 {name=p24 lab=Nctrl}
C {devices/opin.sym} 1445 198.75 0 0 {name=p25 lab=Vout_mux}
C {devices/gnd.sym} 1245 148.75 0 0 {name=l11 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1990 -90 3 0 {name=M1
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1990 -270 1 0 {name=M2
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/gnd.sym} 2070 -70 0 0 {name=l12 lab=GND}
C {inverter.sym} 1660 -300 0 0 {name=X9}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1990 -340 3 0 {name=M3
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1990 -520 1 0 {name=M4
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/opin.sym} 1721.25 -481.25 0 0 {name=p27 lab=Pdrive}
C {devices/vsource.sym} 1876.25 -358.75 0 0 {name=V_DD value=1.8}
C {devices/gnd.sym} 1876.25 -328.75 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2002.5 592.5 3 0 {name=M5
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2002.5 412.5 1 0 {name=M6
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/gnd.sym} 2082.5 612.5 0 0 {name=l15 lab=GND}
C {inverter.sym} 1672.5 382.5 0 0 {name=X10}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2002.5 342.5 3 0 {name=M7
L=0.15
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2002.5 162.5 1 0 {name=M8
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/opin.sym} 1733.75 201.25 0 0 {name=p29 lab=Ndrive}
C {devices/vsource.sym} 1888.75 323.75 0 0 {name=V_DD4 value=1.8}
C {devices/gnd.sym} 1888.75 353.75 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 2412.5 292.5 0 0 {name=l14 lab=GND}
C {devices/vsource.sym} 2412.5 262.5 0 0 {name=V3 value="pwl 0 0 0.08ms 0 0.0801ms 1 0.101ms 1"}
