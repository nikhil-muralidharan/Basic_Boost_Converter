v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 630 -2465 765 -2465 { lab=VLX}
N 765 -2465 915 -2465 { lab=VLX}
N 915 -2465 1075 -2465 { lab=VLX}
N 1075 -2465 1235 -2465 { lab=VLX}
N 630 -2405 765 -2405 { lab=Vout}
N 765 -2405 915 -2405 { lab=Vout}
N 915 -2405 1075 -2405 { lab=Vout}
N 1075 -2405 1235 -2405 { lab=Vout}
N 670 -2435 670 -2360 { lab=Vg}
N 670 -2360 805 -2360 { lab=Vg}
N 805 -2435 805 -2360 { lab=Vg}
N 805 -2360 960 -2360 { lab=Vg}
N 1275 -2435 1275 -2360 { lab=Vg}
N 960 -2360 1275 -2360 { lab=Vg}
N 955 -2435 955 -2360 { lab=Vg}
N 1115 -2435 1115 -2360 { lab=Vg}
N 630 -2465 630 -2435 { lab=VLX}
N 765 -2465 765 -2435 { lab=VLX}
N 915 -2465 915 -2435 { lab=VLX}
N 1075 -2465 1075 -2435 { lab=VLX}
N 1235 -2465 1235 -2435 { lab=VLX}
N 1370 -2465 1505 -2465 { lab=VLX}
N 1505 -2465 1655 -2465 { lab=VLX}
N 1655 -2465 1815 -2465 { lab=VLX}
N 1815 -2465 1975 -2465 { lab=VLX}
N 1370 -2405 1505 -2405 { lab=Vout}
N 1505 -2405 1655 -2405 { lab=Vout}
N 1655 -2405 1815 -2405 { lab=Vout}
N 1815 -2405 1975 -2405 { lab=Vout}
N 1410 -2435 1410 -2360 { lab=Vg}
N 1410 -2360 1545 -2360 { lab=Vg}
N 1545 -2435 1545 -2360 { lab=Vg}
N 1545 -2360 1700 -2360 { lab=Vg}
N 2015 -2435 2015 -2360 { lab=Vg}
N 1700 -2360 2015 -2360 { lab=Vg}
N 1695 -2435 1695 -2360 { lab=Vg}
N 1855 -2435 1855 -2360 { lab=Vg}
N 1370 -2465 1370 -2435 { lab=VLX}
N 1505 -2465 1505 -2435 { lab=VLX}
N 1655 -2465 1655 -2435 { lab=VLX}
N 1815 -2465 1815 -2435 { lab=VLX}
N 1975 -2465 1975 -2435 { lab=VLX}
N 1235 -2465 1370 -2465 { lab=VLX}
N 1235 -2405 1370 -2405 { lab=Vout}
N 1275 -2360 1410 -2360 { lab=Vg}
N 2125 -2465 2260 -2465 { lab=VLX}
N 2260 -2465 2410 -2465 { lab=VLX}
N 2410 -2465 2570 -2465 { lab=VLX}
N 2570 -2465 2730 -2465 { lab=VLX}
N 2125 -2405 2260 -2405 { lab=Vout}
N 2260 -2405 2410 -2405 { lab=Vout}
N 2410 -2405 2570 -2405 { lab=Vout}
N 2570 -2405 2730 -2405 { lab=Vout}
N 2165 -2435 2165 -2360 { lab=Vg}
N 2165 -2360 2300 -2360 { lab=Vg}
N 2300 -2435 2300 -2360 { lab=Vg}
N 2300 -2360 2455 -2360 { lab=Vg}
N 2770 -2435 2770 -2360 { lab=Vg}
N 2455 -2360 2770 -2360 { lab=Vg}
N 2450 -2435 2450 -2360 { lab=Vg}
N 2610 -2435 2610 -2360 { lab=Vg}
N 2125 -2465 2125 -2435 { lab=VLX}
N 2260 -2465 2260 -2435 { lab=VLX}
N 2410 -2465 2410 -2435 { lab=VLX}
N 2570 -2465 2570 -2435 { lab=VLX}
N 2730 -2465 2730 -2435 { lab=VLX}
N 2865 -2465 3000 -2465 { lab=VLX}
N 3000 -2465 3150 -2465 { lab=VLX}
N 3150 -2465 3310 -2465 { lab=VLX}
N 3310 -2465 3470 -2465 { lab=VLX}
N 2865 -2405 3000 -2405 { lab=Vout}
N 3000 -2405 3150 -2405 { lab=Vout}
N 3150 -2405 3310 -2405 { lab=Vout}
N 3310 -2405 3470 -2405 { lab=Vout}
N 2905 -2435 2905 -2360 { lab=Vg}
N 2905 -2360 3040 -2360 { lab=Vg}
N 3040 -2435 3040 -2360 { lab=Vg}
N 3040 -2360 3195 -2360 { lab=Vg}
N 3510 -2435 3510 -2360 { lab=Vg}
N 3195 -2360 3510 -2360 { lab=Vg}
N 3190 -2435 3190 -2360 { lab=Vg}
N 3350 -2435 3350 -2360 { lab=Vg}
N 2865 -2465 2865 -2435 { lab=VLX}
N 3000 -2465 3000 -2435 { lab=VLX}
N 3150 -2465 3150 -2435 { lab=VLX}
N 3310 -2465 3310 -2435 { lab=VLX}
N 3470 -2465 3470 -2435 { lab=VLX}
N 2730 -2465 2865 -2465 { lab=VLX}
N 2730 -2405 2865 -2405 { lab=Vout}
N 2770 -2360 2905 -2360 { lab=Vg}
N 1975 -2465 2125 -2465 { lab=VLX}
N 2015 -2360 2165 -2360 { lab=Vg}
N 1975 -2405 2125 -2405 { lab=Vout}
N 630 -2300 765 -2300 { lab=VLX}
N 765 -2300 915 -2300 { lab=VLX}
N 915 -2300 1075 -2300 { lab=VLX}
N 1075 -2300 1235 -2300 { lab=VLX}
N 630 -2240 765 -2240 { lab=Vout}
N 765 -2240 915 -2240 { lab=Vout}
N 915 -2240 1075 -2240 { lab=Vout}
N 1075 -2240 1235 -2240 { lab=Vout}
N 670 -2270 670 -2195 { lab=Vg}
N 670 -2195 805 -2195 { lab=Vg}
N 805 -2270 805 -2195 { lab=Vg}
N 805 -2195 960 -2195 { lab=Vg}
N 1275 -2270 1275 -2195 { lab=Vg}
N 960 -2195 1275 -2195 { lab=Vg}
N 955 -2270 955 -2195 { lab=Vg}
N 1115 -2270 1115 -2195 { lab=Vg}
N 630 -2300 630 -2270 { lab=VLX}
N 765 -2300 765 -2270 { lab=VLX}
N 915 -2300 915 -2270 { lab=VLX}
N 1075 -2300 1075 -2270 { lab=VLX}
N 1235 -2300 1235 -2270 { lab=VLX}
N 1370 -2300 1505 -2300 { lab=VLX}
N 1505 -2300 1655 -2300 { lab=VLX}
N 1655 -2300 1815 -2300 { lab=VLX}
N 1815 -2300 1975 -2300 { lab=VLX}
N 1370 -2240 1505 -2240 { lab=Vout}
N 1505 -2240 1655 -2240 { lab=Vout}
N 1655 -2240 1815 -2240 { lab=Vout}
N 1815 -2240 1975 -2240 { lab=Vout}
N 1410 -2270 1410 -2195 { lab=Vg}
N 1410 -2195 1545 -2195 { lab=Vg}
N 1545 -2270 1545 -2195 { lab=Vg}
N 1545 -2195 1700 -2195 { lab=Vg}
N 2015 -2270 2015 -2195 { lab=Vg}
N 1700 -2195 2015 -2195 { lab=Vg}
N 1695 -2270 1695 -2195 { lab=Vg}
N 1855 -2270 1855 -2195 { lab=Vg}
N 1370 -2300 1370 -2270 { lab=VLX}
N 1505 -2300 1505 -2270 { lab=VLX}
N 1655 -2300 1655 -2270 { lab=VLX}
N 1815 -2300 1815 -2270 { lab=VLX}
N 1975 -2300 1975 -2270 { lab=VLX}
N 1235 -2300 1370 -2300 { lab=VLX}
N 1235 -2240 1370 -2240 { lab=Vout}
N 1275 -2195 1410 -2195 { lab=Vg}
N 2125 -2300 2260 -2300 { lab=VLX}
N 2260 -2300 2410 -2300 { lab=VLX}
N 2410 -2300 2570 -2300 { lab=VLX}
N 2570 -2300 2730 -2300 { lab=VLX}
N 2125 -2240 2260 -2240 { lab=Vout}
N 2260 -2240 2410 -2240 { lab=Vout}
N 2410 -2240 2570 -2240 { lab=Vout}
N 2570 -2240 2730 -2240 { lab=Vout}
N 2165 -2270 2165 -2195 { lab=Vg}
N 2165 -2195 2300 -2195 { lab=Vg}
N 2300 -2270 2300 -2195 { lab=Vg}
N 2300 -2195 2455 -2195 { lab=Vg}
N 2770 -2270 2770 -2195 { lab=Vg}
N 2455 -2195 2770 -2195 { lab=Vg}
N 2450 -2270 2450 -2195 { lab=Vg}
N 2610 -2270 2610 -2195 { lab=Vg}
N 2125 -2300 2125 -2270 { lab=VLX}
N 2260 -2300 2260 -2270 { lab=VLX}
N 2410 -2300 2410 -2270 { lab=VLX}
N 2570 -2300 2570 -2270 { lab=VLX}
N 2730 -2300 2730 -2270 { lab=VLX}
N 2865 -2300 3000 -2300 { lab=VLX}
N 3000 -2300 3150 -2300 { lab=VLX}
N 3150 -2300 3310 -2300 { lab=VLX}
N 3310 -2300 3470 -2300 { lab=VLX}
N 2865 -2240 3000 -2240 { lab=Vout}
N 3000 -2240 3150 -2240 { lab=Vout}
N 3150 -2240 3310 -2240 { lab=Vout}
N 3310 -2240 3470 -2240 { lab=Vout}
N 2905 -2270 2905 -2195 { lab=Vg}
N 2905 -2195 3040 -2195 { lab=Vg}
N 3040 -2270 3040 -2195 { lab=Vg}
N 3040 -2195 3195 -2195 { lab=Vg}
N 3510 -2270 3510 -2195 { lab=Vg}
N 3195 -2195 3510 -2195 { lab=Vg}
N 3190 -2270 3190 -2195 { lab=Vg}
N 3350 -2270 3350 -2195 { lab=Vg}
N 2865 -2300 2865 -2270 { lab=VLX}
N 3000 -2300 3000 -2270 { lab=VLX}
N 3150 -2300 3150 -2270 { lab=VLX}
N 3310 -2300 3310 -2270 { lab=VLX}
N 3470 -2300 3470 -2270 { lab=VLX}
N 2730 -2300 2865 -2300 { lab=VLX}
N 2730 -2240 2865 -2240 { lab=Vout}
N 2770 -2195 2905 -2195 { lab=Vg}
N 1975 -2300 2125 -2300 { lab=VLX}
N 2015 -2195 2165 -2195 { lab=Vg}
N 1975 -2240 2125 -2240 { lab=Vout}
N 3510 -2360 3510 -2270 { lab=Vg}
N 385 -2465 630 -2465 { lab=VLX}
N 380 -2300 630 -2300 { lab=VLX}
N 380 -2465 380 -2300 { lab=VLX}
N 380 -2465 385 -2465 { lab=VLX}
N 500 -2405 630 -2405 { lab=Vout}
N 630 -2115 765 -2115 { lab=VLX}
N 765 -2115 915 -2115 { lab=VLX}
N 915 -2115 1075 -2115 { lab=VLX}
N 1075 -2115 1235 -2115 { lab=VLX}
N 630 -2055 765 -2055 { lab=Vout}
N 765 -2055 915 -2055 { lab=Vout}
N 915 -2055 1075 -2055 { lab=Vout}
N 1075 -2055 1235 -2055 { lab=Vout}
N 670 -2085 670 -2010 { lab=Vg}
N 670 -2010 805 -2010 { lab=Vg}
N 805 -2085 805 -2010 { lab=Vg}
N 805 -2010 960 -2010 { lab=Vg}
N 1275 -2085 1275 -2010 { lab=Vg}
N 960 -2010 1275 -2010 { lab=Vg}
N 955 -2085 955 -2010 { lab=Vg}
N 1115 -2085 1115 -2010 { lab=Vg}
N 630 -2115 630 -2085 { lab=VLX}
N 765 -2115 765 -2085 { lab=VLX}
N 915 -2115 915 -2085 { lab=VLX}
N 1075 -2115 1075 -2085 { lab=VLX}
N 1235 -2115 1235 -2085 { lab=VLX}
N 1370 -2115 1505 -2115 { lab=VLX}
N 1505 -2115 1655 -2115 { lab=VLX}
N 1655 -2115 1815 -2115 { lab=VLX}
N 1815 -2115 1975 -2115 { lab=VLX}
N 1370 -2055 1505 -2055 { lab=Vout}
N 1505 -2055 1655 -2055 { lab=Vout}
N 1655 -2055 1815 -2055 { lab=Vout}
N 1815 -2055 1975 -2055 { lab=Vout}
N 1410 -2085 1410 -2010 { lab=Vg}
N 1410 -2010 1545 -2010 { lab=Vg}
N 1545 -2085 1545 -2010 { lab=Vg}
N 1545 -2010 1700 -2010 { lab=Vg}
N 2015 -2085 2015 -2010 { lab=Vg}
N 1700 -2010 2015 -2010 { lab=Vg}
N 1695 -2085 1695 -2010 { lab=Vg}
N 1855 -2085 1855 -2010 { lab=Vg}
N 1370 -2115 1370 -2085 { lab=VLX}
N 1505 -2115 1505 -2085 { lab=VLX}
N 1655 -2115 1655 -2085 { lab=VLX}
N 1815 -2115 1815 -2085 { lab=VLX}
N 1975 -2115 1975 -2085 { lab=VLX}
N 1235 -2115 1370 -2115 { lab=VLX}
N 1235 -2055 1370 -2055 { lab=Vout}
N 1275 -2010 1410 -2010 { lab=Vg}
N 2125 -2115 2260 -2115 { lab=VLX}
N 2260 -2115 2410 -2115 { lab=VLX}
N 2410 -2115 2570 -2115 { lab=VLX}
N 2570 -2115 2730 -2115 { lab=VLX}
N 2125 -2055 2260 -2055 { lab=Vout}
N 2260 -2055 2410 -2055 { lab=Vout}
N 2410 -2055 2570 -2055 { lab=Vout}
N 2570 -2055 2730 -2055 { lab=Vout}
N 2165 -2085 2165 -2010 { lab=Vg}
N 2165 -2010 2300 -2010 { lab=Vg}
N 2300 -2085 2300 -2010 { lab=Vg}
N 2300 -2010 2455 -2010 { lab=Vg}
N 2770 -2085 2770 -2010 { lab=Vg}
N 2455 -2010 2770 -2010 { lab=Vg}
N 2450 -2085 2450 -2010 { lab=Vg}
N 2610 -2085 2610 -2010 { lab=Vg}
N 2125 -2115 2125 -2085 { lab=VLX}
N 2260 -2115 2260 -2085 { lab=VLX}
N 2410 -2115 2410 -2085 { lab=VLX}
N 2570 -2115 2570 -2085 { lab=VLX}
N 2730 -2115 2730 -2085 { lab=VLX}
N 2865 -2115 3000 -2115 { lab=VLX}
N 3000 -2115 3150 -2115 { lab=VLX}
N 3150 -2115 3310 -2115 { lab=VLX}
N 3310 -2115 3470 -2115 { lab=VLX}
N 2865 -2055 3000 -2055 { lab=Vout}
N 3000 -2055 3150 -2055 { lab=Vout}
N 3150 -2055 3310 -2055 { lab=Vout}
N 3310 -2055 3470 -2055 { lab=Vout}
N 2905 -2085 2905 -2010 { lab=Vg}
N 2905 -2010 3040 -2010 { lab=Vg}
N 3040 -2085 3040 -2010 { lab=Vg}
N 3040 -2010 3195 -2010 { lab=Vg}
N 3510 -2085 3510 -2010 { lab=Vg}
N 3195 -2010 3510 -2010 { lab=Vg}
N 3190 -2085 3190 -2010 { lab=Vg}
N 3350 -2085 3350 -2010 { lab=Vg}
N 2865 -2115 2865 -2085 { lab=VLX}
N 3000 -2115 3000 -2085 { lab=VLX}
N 3150 -2115 3150 -2085 { lab=VLX}
N 3310 -2115 3310 -2085 { lab=VLX}
N 3470 -2115 3470 -2085 { lab=VLX}
N 2730 -2115 2865 -2115 { lab=VLX}
N 2730 -2055 2865 -2055 { lab=Vout}
N 2770 -2010 2905 -2010 { lab=Vg}
N 1975 -2115 2125 -2115 { lab=VLX}
N 2015 -2010 2165 -2010 { lab=Vg}
N 1975 -2055 2125 -2055 { lab=Vout}
N 630 -1950 765 -1950 { lab=VLX}
N 765 -1950 915 -1950 { lab=VLX}
N 915 -1950 1075 -1950 { lab=VLX}
N 1075 -1950 1235 -1950 { lab=VLX}
N 630 -1890 765 -1890 { lab=Vout}
N 765 -1890 915 -1890 { lab=Vout}
N 915 -1890 1075 -1890 { lab=Vout}
N 1075 -1890 1235 -1890 { lab=Vout}
N 670 -1920 670 -1845 { lab=Vg}
N 670 -1845 805 -1845 { lab=Vg}
N 805 -1920 805 -1845 { lab=Vg}
N 805 -1845 960 -1845 { lab=Vg}
N 1275 -1920 1275 -1845 { lab=Vg}
N 960 -1845 1275 -1845 { lab=Vg}
N 955 -1920 955 -1845 { lab=Vg}
N 1115 -1920 1115 -1845 { lab=Vg}
N 630 -1950 630 -1920 { lab=VLX}
N 765 -1950 765 -1920 { lab=VLX}
N 915 -1950 915 -1920 { lab=VLX}
N 1075 -1950 1075 -1920 { lab=VLX}
N 1235 -1950 1235 -1920 { lab=VLX}
N 1370 -1950 1505 -1950 { lab=VLX}
N 1505 -1950 1655 -1950 { lab=VLX}
N 1655 -1950 1815 -1950 { lab=VLX}
N 1815 -1950 1975 -1950 { lab=VLX}
N 1370 -1890 1505 -1890 { lab=Vout}
N 1505 -1890 1655 -1890 { lab=Vout}
N 1655 -1890 1815 -1890 { lab=Vout}
N 1815 -1890 1975 -1890 { lab=Vout}
N 1410 -1920 1410 -1845 { lab=Vg}
N 1410 -1845 1545 -1845 { lab=Vg}
N 1545 -1920 1545 -1845 { lab=Vg}
N 1545 -1845 1700 -1845 { lab=Vg}
N 2015 -1920 2015 -1845 { lab=Vg}
N 1700 -1845 2015 -1845 { lab=Vg}
N 1695 -1920 1695 -1845 { lab=Vg}
N 1855 -1920 1855 -1845 { lab=Vg}
N 1370 -1950 1370 -1920 { lab=VLX}
N 1505 -1950 1505 -1920 { lab=VLX}
N 1655 -1950 1655 -1920 { lab=VLX}
N 1815 -1950 1815 -1920 { lab=VLX}
N 1975 -1950 1975 -1920 { lab=VLX}
N 1235 -1950 1370 -1950 { lab=VLX}
N 1235 -1890 1370 -1890 { lab=Vout}
N 1275 -1845 1410 -1845 { lab=Vg}
N 2125 -1950 2260 -1950 { lab=VLX}
N 2260 -1950 2410 -1950 { lab=VLX}
N 2410 -1950 2570 -1950 { lab=VLX}
N 2570 -1950 2730 -1950 { lab=VLX}
N 2125 -1890 2260 -1890 { lab=Vout}
N 2260 -1890 2410 -1890 { lab=Vout}
N 2410 -1890 2570 -1890 { lab=Vout}
N 2570 -1890 2730 -1890 { lab=Vout}
N 2165 -1920 2165 -1845 { lab=Vg}
N 2165 -1845 2300 -1845 { lab=Vg}
N 2300 -1920 2300 -1845 { lab=Vg}
N 2300 -1845 2455 -1845 { lab=Vg}
N 2770 -1920 2770 -1845 { lab=Vg}
N 2455 -1845 2770 -1845 { lab=Vg}
N 2450 -1920 2450 -1845 { lab=Vg}
N 2610 -1920 2610 -1845 { lab=Vg}
N 2125 -1950 2125 -1920 { lab=VLX}
N 2260 -1950 2260 -1920 { lab=VLX}
N 2410 -1950 2410 -1920 { lab=VLX}
N 2570 -1950 2570 -1920 { lab=VLX}
N 2730 -1950 2730 -1920 { lab=VLX}
N 2865 -1950 3000 -1950 { lab=VLX}
N 3000 -1950 3150 -1950 { lab=VLX}
N 3150 -1950 3310 -1950 { lab=VLX}
N 3310 -1950 3470 -1950 { lab=VLX}
N 2865 -1890 3000 -1890 { lab=Vout}
N 3000 -1890 3150 -1890 { lab=Vout}
N 3150 -1890 3310 -1890 { lab=Vout}
N 3310 -1890 3470 -1890 { lab=Vout}
N 2905 -1920 2905 -1845 { lab=Vg}
N 2905 -1845 3040 -1845 { lab=Vg}
N 3040 -1920 3040 -1845 { lab=Vg}
N 3040 -1845 3195 -1845 { lab=Vg}
N 3510 -1920 3510 -1845 { lab=Vg}
N 3195 -1845 3510 -1845 { lab=Vg}
N 3190 -1920 3190 -1845 { lab=Vg}
N 3350 -1920 3350 -1845 { lab=Vg}
N 2865 -1950 2865 -1920 { lab=VLX}
N 3000 -1950 3000 -1920 { lab=VLX}
N 3150 -1950 3150 -1920 { lab=VLX}
N 3310 -1950 3310 -1920 { lab=VLX}
N 3470 -1950 3470 -1920 { lab=VLX}
N 2730 -1950 2865 -1950 { lab=VLX}
N 2730 -1890 2865 -1890 { lab=Vout}
N 2770 -1845 2905 -1845 { lab=Vg}
N 1975 -1950 2125 -1950 { lab=VLX}
N 2015 -1845 2165 -1845 { lab=Vg}
N 1975 -1890 2125 -1890 { lab=Vout}
N 3510 -2010 3510 -1920 { lab=Vg}
N 385 -2115 630 -2115 { lab=VLX}
N 380 -1950 630 -1950 { lab=VLX}
N 380 -2115 380 -1950 { lab=VLX}
N 380 -2115 385 -2115 { lab=VLX}
N 500 -2055 500 -1845 { lab=Vout}
N 380 -2300 380 -2110 { lab=VLX}
N 500 -2200 500 -2050 { lab=Vout}
N 3510 -2200 3510 -2080 { lab=Vg}
N 630 -1795 765 -1795 { lab=VLX}
N 765 -1795 915 -1795 { lab=VLX}
N 915 -1795 1075 -1795 { lab=VLX}
N 1075 -1795 1235 -1795 { lab=VLX}
N 630 -1735 765 -1735 { lab=Vout}
N 765 -1735 915 -1735 { lab=Vout}
N 915 -1735 1075 -1735 { lab=Vout}
N 1075 -1735 1235 -1735 { lab=Vout}
N 670 -1765 670 -1690 { lab=Vg}
N 670 -1690 805 -1690 { lab=Vg}
N 805 -1765 805 -1690 { lab=Vg}
N 805 -1690 960 -1690 { lab=Vg}
N 1275 -1765 1275 -1690 { lab=Vg}
N 960 -1690 1275 -1690 { lab=Vg}
N 955 -1765 955 -1690 { lab=Vg}
N 1115 -1765 1115 -1690 { lab=Vg}
N 630 -1795 630 -1765 { lab=VLX}
N 765 -1795 765 -1765 { lab=VLX}
N 915 -1795 915 -1765 { lab=VLX}
N 1075 -1795 1075 -1765 { lab=VLX}
N 1235 -1795 1235 -1765 { lab=VLX}
N 1370 -1795 1505 -1795 { lab=VLX}
N 1505 -1795 1655 -1795 { lab=VLX}
N 1655 -1795 1815 -1795 { lab=VLX}
N 1815 -1795 1975 -1795 { lab=VLX}
N 1370 -1735 1505 -1735 { lab=Vout}
N 1505 -1735 1655 -1735 { lab=Vout}
N 1655 -1735 1815 -1735 { lab=Vout}
N 1815 -1735 1975 -1735 { lab=Vout}
N 1410 -1765 1410 -1690 { lab=Vg}
N 1410 -1690 1545 -1690 { lab=Vg}
N 1545 -1765 1545 -1690 { lab=Vg}
N 1545 -1690 1700 -1690 { lab=Vg}
N 2015 -1765 2015 -1690 { lab=Vg}
N 1700 -1690 2015 -1690 { lab=Vg}
N 1695 -1765 1695 -1690 { lab=Vg}
N 1855 -1765 1855 -1690 { lab=Vg}
N 1370 -1795 1370 -1765 { lab=VLX}
N 1505 -1795 1505 -1765 { lab=VLX}
N 1655 -1795 1655 -1765 { lab=VLX}
N 1815 -1795 1815 -1765 { lab=VLX}
N 1975 -1795 1975 -1765 { lab=VLX}
N 1235 -1795 1370 -1795 { lab=VLX}
N 1235 -1735 1370 -1735 { lab=Vout}
N 1275 -1690 1410 -1690 { lab=Vg}
N 2125 -1795 2260 -1795 { lab=VLX}
N 2260 -1795 2410 -1795 { lab=VLX}
N 2410 -1795 2570 -1795 { lab=VLX}
N 2570 -1795 2730 -1795 { lab=VLX}
N 2125 -1735 2260 -1735 { lab=Vout}
N 2260 -1735 2410 -1735 { lab=Vout}
N 2410 -1735 2570 -1735 { lab=Vout}
N 2570 -1735 2730 -1735 { lab=Vout}
N 2165 -1765 2165 -1690 { lab=Vg}
N 2165 -1690 2300 -1690 { lab=Vg}
N 2300 -1765 2300 -1690 { lab=Vg}
N 2300 -1690 2455 -1690 { lab=Vg}
N 2770 -1765 2770 -1690 { lab=Vg}
N 2455 -1690 2770 -1690 { lab=Vg}
N 2450 -1765 2450 -1690 { lab=Vg}
N 2610 -1765 2610 -1690 { lab=Vg}
N 2125 -1795 2125 -1765 { lab=VLX}
N 2260 -1795 2260 -1765 { lab=VLX}
N 2410 -1795 2410 -1765 { lab=VLX}
N 2570 -1795 2570 -1765 { lab=VLX}
N 2730 -1795 2730 -1765 { lab=VLX}
N 2865 -1795 3000 -1795 { lab=VLX}
N 3000 -1795 3150 -1795 { lab=VLX}
N 3150 -1795 3310 -1795 { lab=VLX}
N 3310 -1795 3470 -1795 { lab=VLX}
N 2865 -1735 3000 -1735 { lab=Vout}
N 3000 -1735 3150 -1735 { lab=Vout}
N 3150 -1735 3310 -1735 { lab=Vout}
N 3310 -1735 3470 -1735 { lab=Vout}
N 2905 -1765 2905 -1690 { lab=Vg}
N 2905 -1690 3040 -1690 { lab=Vg}
N 3040 -1765 3040 -1690 { lab=Vg}
N 3040 -1690 3195 -1690 { lab=Vg}
N 3510 -1765 3510 -1690 { lab=Vg}
N 3195 -1690 3510 -1690 { lab=Vg}
N 3190 -1765 3190 -1690 { lab=Vg}
N 3350 -1765 3350 -1690 { lab=Vg}
N 2865 -1795 2865 -1765 { lab=VLX}
N 3000 -1795 3000 -1765 { lab=VLX}
N 3150 -1795 3150 -1765 { lab=VLX}
N 3310 -1795 3310 -1765 { lab=VLX}
N 3470 -1795 3470 -1765 { lab=VLX}
N 2730 -1795 2865 -1795 { lab=VLX}
N 2730 -1735 2865 -1735 { lab=Vout}
N 2770 -1690 2905 -1690 { lab=Vg}
N 1975 -1795 2125 -1795 { lab=VLX}
N 2015 -1690 2165 -1690 { lab=Vg}
N 1975 -1735 2125 -1735 { lab=Vout}
N 630 -1630 765 -1630 { lab=VLX}
N 765 -1630 915 -1630 { lab=VLX}
N 915 -1630 1075 -1630 { lab=VLX}
N 1075 -1630 1235 -1630 { lab=VLX}
N 630 -1570 765 -1570 { lab=Vout}
N 765 -1570 915 -1570 { lab=Vout}
N 915 -1570 1075 -1570 { lab=Vout}
N 1075 -1570 1235 -1570 { lab=Vout}
N 670 -1600 670 -1525 { lab=Vg}
N 670 -1525 805 -1525 { lab=Vg}
N 805 -1600 805 -1525 { lab=Vg}
N 805 -1525 960 -1525 { lab=Vg}
N 1275 -1600 1275 -1525 { lab=Vg}
N 960 -1525 1275 -1525 { lab=Vg}
N 955 -1600 955 -1525 { lab=Vg}
N 1115 -1600 1115 -1525 { lab=Vg}
N 630 -1630 630 -1600 { lab=VLX}
N 765 -1630 765 -1600 { lab=VLX}
N 915 -1630 915 -1600 { lab=VLX}
N 1075 -1630 1075 -1600 { lab=VLX}
N 1235 -1630 1235 -1600 { lab=VLX}
N 1370 -1630 1505 -1630 { lab=VLX}
N 1505 -1630 1655 -1630 { lab=VLX}
N 1655 -1630 1815 -1630 { lab=VLX}
N 1815 -1630 1975 -1630 { lab=VLX}
N 1370 -1570 1505 -1570 { lab=Vout}
N 1505 -1570 1655 -1570 { lab=Vout}
N 1655 -1570 1815 -1570 { lab=Vout}
N 1815 -1570 1975 -1570 { lab=Vout}
N 1410 -1600 1410 -1525 { lab=Vg}
N 1410 -1525 1545 -1525 { lab=Vg}
N 1545 -1600 1545 -1525 { lab=Vg}
N 1545 -1525 1700 -1525 { lab=Vg}
N 2015 -1600 2015 -1525 { lab=Vg}
N 1700 -1525 2015 -1525 { lab=Vg}
N 1695 -1600 1695 -1525 { lab=Vg}
N 1855 -1600 1855 -1525 { lab=Vg}
N 1370 -1630 1370 -1600 { lab=VLX}
N 1505 -1630 1505 -1600 { lab=VLX}
N 1655 -1630 1655 -1600 { lab=VLX}
N 1815 -1630 1815 -1600 { lab=VLX}
N 1975 -1630 1975 -1600 { lab=VLX}
N 1235 -1630 1370 -1630 { lab=VLX}
N 1235 -1570 1370 -1570 { lab=Vout}
N 1275 -1525 1410 -1525 { lab=Vg}
N 2125 -1630 2260 -1630 { lab=VLX}
N 2260 -1630 2410 -1630 { lab=VLX}
N 2410 -1630 2570 -1630 { lab=VLX}
N 2570 -1630 2730 -1630 { lab=VLX}
N 2125 -1570 2260 -1570 { lab=Vout}
N 2260 -1570 2410 -1570 { lab=Vout}
N 2410 -1570 2570 -1570 { lab=Vout}
N 2570 -1570 2730 -1570 { lab=Vout}
N 2165 -1600 2165 -1525 { lab=Vg}
N 2165 -1525 2300 -1525 { lab=Vg}
N 2300 -1600 2300 -1525 { lab=Vg}
N 2300 -1525 2455 -1525 { lab=Vg}
N 2770 -1600 2770 -1525 { lab=Vg}
N 2455 -1525 2770 -1525 { lab=Vg}
N 2450 -1600 2450 -1525 { lab=Vg}
N 2610 -1600 2610 -1525 { lab=Vg}
N 2125 -1630 2125 -1600 { lab=VLX}
N 2260 -1630 2260 -1600 { lab=VLX}
N 2410 -1630 2410 -1600 { lab=VLX}
N 2570 -1630 2570 -1600 { lab=VLX}
N 2730 -1630 2730 -1600 { lab=VLX}
N 2865 -1630 3000 -1630 { lab=VLX}
N 3000 -1630 3150 -1630 { lab=VLX}
N 3150 -1630 3310 -1630 { lab=VLX}
N 3310 -1630 3470 -1630 { lab=VLX}
N 2865 -1570 3000 -1570 { lab=Vout}
N 3000 -1570 3150 -1570 { lab=Vout}
N 3150 -1570 3310 -1570 { lab=Vout}
N 3310 -1570 3470 -1570 { lab=Vout}
N 2905 -1600 2905 -1525 { lab=Vg}
N 2905 -1525 3040 -1525 { lab=Vg}
N 3040 -1600 3040 -1525 { lab=Vg}
N 3040 -1525 3195 -1525 { lab=Vg}
N 3510 -1600 3510 -1525 { lab=Vg}
N 3195 -1525 3510 -1525 { lab=Vg}
N 3190 -1600 3190 -1525 { lab=Vg}
N 3350 -1600 3350 -1525 { lab=Vg}
N 2865 -1630 2865 -1600 { lab=VLX}
N 3000 -1630 3000 -1600 { lab=VLX}
N 3150 -1630 3150 -1600 { lab=VLX}
N 3310 -1630 3310 -1600 { lab=VLX}
N 3470 -1630 3470 -1600 { lab=VLX}
N 2730 -1630 2865 -1630 { lab=VLX}
N 2730 -1570 2865 -1570 { lab=Vout}
N 2770 -1525 2905 -1525 { lab=Vg}
N 1975 -1630 2125 -1630 { lab=VLX}
N 2015 -1525 2165 -1525 { lab=Vg}
N 1975 -1570 2125 -1570 { lab=Vout}
N 3510 -1690 3510 -1600 { lab=Vg}
N 385 -1795 630 -1795 { lab=VLX}
N 380 -1630 630 -1630 { lab=VLX}
N 380 -1795 380 -1630 { lab=VLX}
N 380 -1795 385 -1795 { lab=VLX}
N 500 -1735 500 -1525 { lab=Vout}
N 630 -1445 765 -1445 { lab=VLX}
N 765 -1445 915 -1445 { lab=VLX}
N 915 -1445 1075 -1445 { lab=VLX}
N 1075 -1445 1235 -1445 { lab=VLX}
N 630 -1385 765 -1385 { lab=Vout}
N 765 -1385 915 -1385 { lab=Vout}
N 915 -1385 1075 -1385 { lab=Vout}
N 1075 -1385 1235 -1385 { lab=Vout}
N 670 -1415 670 -1340 { lab=Vg}
N 670 -1340 805 -1340 { lab=Vg}
N 805 -1415 805 -1340 { lab=Vg}
N 805 -1340 960 -1340 { lab=Vg}
N 1275 -1415 1275 -1340 { lab=Vg}
N 960 -1340 1275 -1340 { lab=Vg}
N 955 -1415 955 -1340 { lab=Vg}
N 1115 -1415 1115 -1340 { lab=Vg}
N 630 -1445 630 -1415 { lab=VLX}
N 765 -1445 765 -1415 { lab=VLX}
N 915 -1445 915 -1415 { lab=VLX}
N 1075 -1445 1075 -1415 { lab=VLX}
N 1235 -1445 1235 -1415 { lab=VLX}
N 1370 -1445 1505 -1445 { lab=VLX}
N 1505 -1445 1655 -1445 { lab=VLX}
N 1655 -1445 1815 -1445 { lab=VLX}
N 1815 -1445 1975 -1445 { lab=VLX}
N 1370 -1385 1505 -1385 { lab=Vout}
N 1505 -1385 1655 -1385 { lab=Vout}
N 1655 -1385 1815 -1385 { lab=Vout}
N 1815 -1385 1975 -1385 { lab=Vout}
N 1410 -1415 1410 -1340 { lab=Vg}
N 1410 -1340 1545 -1340 { lab=Vg}
N 1545 -1415 1545 -1340 { lab=Vg}
N 1545 -1340 1700 -1340 { lab=Vg}
N 2015 -1415 2015 -1340 { lab=Vg}
N 1700 -1340 2015 -1340 { lab=Vg}
N 1695 -1415 1695 -1340 { lab=Vg}
N 1855 -1415 1855 -1340 { lab=Vg}
N 1370 -1445 1370 -1415 { lab=VLX}
N 1505 -1445 1505 -1415 { lab=VLX}
N 1655 -1445 1655 -1415 { lab=VLX}
N 1815 -1445 1815 -1415 { lab=VLX}
N 1975 -1445 1975 -1415 { lab=VLX}
N 1235 -1445 1370 -1445 { lab=VLX}
N 1235 -1385 1370 -1385 { lab=Vout}
N 1275 -1340 1410 -1340 { lab=Vg}
N 2125 -1445 2260 -1445 { lab=VLX}
N 2260 -1445 2410 -1445 { lab=VLX}
N 2410 -1445 2570 -1445 { lab=VLX}
N 2570 -1445 2730 -1445 { lab=VLX}
N 2125 -1385 2260 -1385 { lab=Vout}
N 2260 -1385 2410 -1385 { lab=Vout}
N 2410 -1385 2570 -1385 { lab=Vout}
N 2570 -1385 2730 -1385 { lab=Vout}
N 2165 -1415 2165 -1340 { lab=Vg}
N 2165 -1340 2300 -1340 { lab=Vg}
N 2300 -1415 2300 -1340 { lab=Vg}
N 2300 -1340 2455 -1340 { lab=Vg}
N 2770 -1415 2770 -1340 { lab=Vg}
N 2455 -1340 2770 -1340 { lab=Vg}
N 2450 -1415 2450 -1340 { lab=Vg}
N 2610 -1415 2610 -1340 { lab=Vg}
N 2125 -1445 2125 -1415 { lab=VLX}
N 2260 -1445 2260 -1415 { lab=VLX}
N 2410 -1445 2410 -1415 { lab=VLX}
N 2570 -1445 2570 -1415 { lab=VLX}
N 2730 -1445 2730 -1415 { lab=VLX}
N 2865 -1445 3000 -1445 { lab=VLX}
N 3000 -1445 3150 -1445 { lab=VLX}
N 3150 -1445 3310 -1445 { lab=VLX}
N 3310 -1445 3470 -1445 { lab=VLX}
N 2865 -1385 3000 -1385 { lab=Vout}
N 3000 -1385 3150 -1385 { lab=Vout}
N 3150 -1385 3310 -1385 { lab=Vout}
N 3310 -1385 3470 -1385 { lab=Vout}
N 2905 -1415 2905 -1340 { lab=Vg}
N 2905 -1340 3040 -1340 { lab=Vg}
N 3040 -1415 3040 -1340 { lab=Vg}
N 3040 -1340 3195 -1340 { lab=Vg}
N 3510 -1415 3510 -1340 { lab=Vg}
N 3195 -1340 3510 -1340 { lab=Vg}
N 3190 -1415 3190 -1340 { lab=Vg}
N 3350 -1415 3350 -1340 { lab=Vg}
N 2865 -1445 2865 -1415 { lab=VLX}
N 3000 -1445 3000 -1415 { lab=VLX}
N 3150 -1445 3150 -1415 { lab=VLX}
N 3310 -1445 3310 -1415 { lab=VLX}
N 3470 -1445 3470 -1415 { lab=VLX}
N 2730 -1445 2865 -1445 { lab=VLX}
N 2730 -1385 2865 -1385 { lab=Vout}
N 2770 -1340 2905 -1340 { lab=Vg}
N 1975 -1445 2125 -1445 { lab=VLX}
N 2015 -1340 2165 -1340 { lab=Vg}
N 1975 -1385 2125 -1385 { lab=Vout}
N 630 -1280 765 -1280 { lab=VLX}
N 765 -1280 915 -1280 { lab=VLX}
N 915 -1280 1075 -1280 { lab=VLX}
N 1075 -1280 1235 -1280 { lab=VLX}
N 630 -1220 765 -1220 { lab=Vout}
N 765 -1220 915 -1220 { lab=Vout}
N 915 -1220 1075 -1220 { lab=Vout}
N 1075 -1220 1235 -1220 { lab=Vout}
N 670 -1250 670 -1175 { lab=Vg}
N 670 -1175 805 -1175 { lab=Vg}
N 805 -1250 805 -1175 { lab=Vg}
N 805 -1175 960 -1175 { lab=Vg}
N 1275 -1250 1275 -1175 { lab=Vg}
N 960 -1175 1275 -1175 { lab=Vg}
N 955 -1250 955 -1175 { lab=Vg}
N 1115 -1250 1115 -1175 { lab=Vg}
N 630 -1280 630 -1250 { lab=VLX}
N 765 -1280 765 -1250 { lab=VLX}
N 915 -1280 915 -1250 { lab=VLX}
N 1075 -1280 1075 -1250 { lab=VLX}
N 1235 -1280 1235 -1250 { lab=VLX}
N 1370 -1280 1505 -1280 { lab=VLX}
N 1505 -1280 1655 -1280 { lab=VLX}
N 1655 -1280 1815 -1280 { lab=VLX}
N 1815 -1280 1975 -1280 { lab=VLX}
N 1370 -1220 1505 -1220 { lab=Vout}
N 1505 -1220 1655 -1220 { lab=Vout}
N 1655 -1220 1815 -1220 { lab=Vout}
N 1815 -1220 1975 -1220 { lab=Vout}
N 1410 -1250 1410 -1175 { lab=Vg}
N 1410 -1175 1545 -1175 { lab=Vg}
N 1545 -1250 1545 -1175 { lab=Vg}
N 1545 -1175 1700 -1175 { lab=Vg}
N 2015 -1250 2015 -1175 { lab=Vg}
N 1700 -1175 2015 -1175 { lab=Vg}
N 1695 -1250 1695 -1175 { lab=Vg}
N 1855 -1250 1855 -1175 { lab=Vg}
N 1370 -1280 1370 -1250 { lab=VLX}
N 1505 -1280 1505 -1250 { lab=VLX}
N 1655 -1280 1655 -1250 { lab=VLX}
N 1815 -1280 1815 -1250 { lab=VLX}
N 1975 -1280 1975 -1250 { lab=VLX}
N 1235 -1280 1370 -1280 { lab=VLX}
N 1235 -1220 1370 -1220 { lab=Vout}
N 1275 -1175 1410 -1175 { lab=Vg}
N 2125 -1280 2260 -1280 { lab=VLX}
N 2260 -1280 2410 -1280 { lab=VLX}
N 2410 -1280 2570 -1280 { lab=VLX}
N 2570 -1280 2730 -1280 { lab=VLX}
N 2125 -1220 2260 -1220 { lab=Vout}
N 2260 -1220 2410 -1220 { lab=Vout}
N 2410 -1220 2570 -1220 { lab=Vout}
N 2570 -1220 2730 -1220 { lab=Vout}
N 2165 -1250 2165 -1175 { lab=Vg}
N 2165 -1175 2300 -1175 { lab=Vg}
N 2300 -1250 2300 -1175 { lab=Vg}
N 2300 -1175 2455 -1175 { lab=Vg}
N 2770 -1250 2770 -1175 { lab=Vg}
N 2455 -1175 2770 -1175 { lab=Vg}
N 2450 -1250 2450 -1175 { lab=Vg}
N 2610 -1250 2610 -1175 { lab=Vg}
N 2125 -1280 2125 -1250 { lab=VLX}
N 2260 -1280 2260 -1250 { lab=VLX}
N 2410 -1280 2410 -1250 { lab=VLX}
N 2570 -1280 2570 -1250 { lab=VLX}
N 2730 -1280 2730 -1250 { lab=VLX}
N 2865 -1280 3000 -1280 { lab=VLX}
N 3000 -1280 3150 -1280 { lab=VLX}
N 3150 -1280 3310 -1280 { lab=VLX}
N 3310 -1280 3470 -1280 { lab=VLX}
N 2865 -1220 3000 -1220 { lab=Vout}
N 3000 -1220 3150 -1220 { lab=Vout}
N 3150 -1220 3310 -1220 { lab=Vout}
N 3310 -1220 3470 -1220 { lab=Vout}
N 2905 -1250 2905 -1175 { lab=Vg}
N 2905 -1175 3040 -1175 { lab=Vg}
N 3040 -1250 3040 -1175 { lab=Vg}
N 3040 -1175 3195 -1175 { lab=Vg}
N 3510 -1250 3510 -1175 { lab=Vg}
N 3195 -1175 3510 -1175 { lab=Vg}
N 3190 -1250 3190 -1175 { lab=Vg}
N 3350 -1250 3350 -1175 { lab=Vg}
N 2865 -1280 2865 -1250 { lab=VLX}
N 3000 -1280 3000 -1250 { lab=VLX}
N 3150 -1280 3150 -1250 { lab=VLX}
N 3310 -1280 3310 -1250 { lab=VLX}
N 3470 -1280 3470 -1250 { lab=VLX}
N 2730 -1280 2865 -1280 { lab=VLX}
N 2730 -1220 2865 -1220 { lab=Vout}
N 2770 -1175 2905 -1175 { lab=Vg}
N 1975 -1280 2125 -1280 { lab=VLX}
N 2015 -1175 2165 -1175 { lab=Vg}
N 1975 -1220 2125 -1220 { lab=Vout}
N 3510 -1340 3510 -1250 { lab=Vg}
N 385 -1445 630 -1445 { lab=VLX}
N 380 -1280 630 -1280 { lab=VLX}
N 380 -1445 380 -1280 { lab=VLX}
N 380 -1445 385 -1445 { lab=VLX}
N 500 -1385 500 -1175 { lab=Vout}
N 380 -1630 380 -1440 { lab=VLX}
N 500 -1530 500 -1380 { lab=Vout}
N 3510 -1530 3510 -1410 { lab=Vg}
N 380 -1950 380 -1790 { lab=VLX}
N 500 -1850 500 -1730 { lab=Vout}
N 3510 -1840 3510 -1770 { lab=Vg}
N 3510 -1850 3510 -1840 { lab=Vg}
N 630 -1045 765 -1045 { lab=VLX}
N 765 -1045 915 -1045 { lab=VLX}
N 915 -1045 1075 -1045 { lab=VLX}
N 1075 -1045 1235 -1045 { lab=VLX}
N 630 -985 765 -985 { lab=Vout}
N 765 -985 915 -985 { lab=Vout}
N 915 -985 1075 -985 { lab=Vout}
N 1075 -985 1235 -985 { lab=Vout}
N 670 -1015 670 -940 { lab=Vg}
N 670 -940 805 -940 { lab=Vg}
N 805 -1015 805 -940 { lab=Vg}
N 805 -940 960 -940 { lab=Vg}
N 1275 -1015 1275 -940 { lab=Vg}
N 960 -940 1275 -940 { lab=Vg}
N 955 -1015 955 -940 { lab=Vg}
N 1115 -1015 1115 -940 { lab=Vg}
N 630 -1045 630 -1015 { lab=VLX}
N 765 -1045 765 -1015 { lab=VLX}
N 915 -1045 915 -1015 { lab=VLX}
N 1075 -1045 1075 -1015 { lab=VLX}
N 1235 -1045 1235 -1015 { lab=VLX}
N 1370 -1045 1505 -1045 { lab=VLX}
N 1505 -1045 1655 -1045 { lab=VLX}
N 1655 -1045 1815 -1045 { lab=VLX}
N 1815 -1045 1975 -1045 { lab=VLX}
N 1370 -985 1505 -985 { lab=Vout}
N 1505 -985 1655 -985 { lab=Vout}
N 1655 -985 1815 -985 { lab=Vout}
N 1815 -985 1975 -985 { lab=Vout}
N 1410 -1015 1410 -940 { lab=Vg}
N 1410 -940 1545 -940 { lab=Vg}
N 1545 -1015 1545 -940 { lab=Vg}
N 1545 -940 1700 -940 { lab=Vg}
N 2015 -1015 2015 -940 { lab=Vg}
N 1700 -940 2015 -940 { lab=Vg}
N 1695 -1015 1695 -940 { lab=Vg}
N 1855 -1015 1855 -940 { lab=Vg}
N 1370 -1045 1370 -1015 { lab=VLX}
N 1505 -1045 1505 -1015 { lab=VLX}
N 1655 -1045 1655 -1015 { lab=VLX}
N 1815 -1045 1815 -1015 { lab=VLX}
N 1975 -1045 1975 -1015 { lab=VLX}
N 1235 -1045 1370 -1045 { lab=VLX}
N 1235 -985 1370 -985 { lab=Vout}
N 1275 -940 1410 -940 { lab=Vg}
N 2125 -1045 2260 -1045 { lab=VLX}
N 2260 -1045 2410 -1045 { lab=VLX}
N 2410 -1045 2570 -1045 { lab=VLX}
N 2570 -1045 2730 -1045 { lab=VLX}
N 2125 -985 2260 -985 { lab=Vout}
N 2260 -985 2410 -985 { lab=Vout}
N 2410 -985 2570 -985 { lab=Vout}
N 2570 -985 2730 -985 { lab=Vout}
N 2165 -1015 2165 -940 { lab=Vg}
N 2165 -940 2300 -940 { lab=Vg}
N 2300 -1015 2300 -940 { lab=Vg}
N 2300 -940 2455 -940 { lab=Vg}
N 2770 -1015 2770 -940 { lab=Vg}
N 2455 -940 2770 -940 { lab=Vg}
N 2450 -1015 2450 -940 { lab=Vg}
N 2610 -1015 2610 -940 { lab=Vg}
N 2125 -1045 2125 -1015 { lab=VLX}
N 2260 -1045 2260 -1015 { lab=VLX}
N 2410 -1045 2410 -1015 { lab=VLX}
N 2570 -1045 2570 -1015 { lab=VLX}
N 2730 -1045 2730 -1015 { lab=VLX}
N 2865 -1045 3000 -1045 { lab=VLX}
N 3000 -1045 3150 -1045 { lab=VLX}
N 3150 -1045 3310 -1045 { lab=VLX}
N 3310 -1045 3470 -1045 { lab=VLX}
N 2865 -985 3000 -985 { lab=Vout}
N 3000 -985 3150 -985 { lab=Vout}
N 3150 -985 3310 -985 { lab=Vout}
N 3310 -985 3470 -985 { lab=Vout}
N 2905 -1015 2905 -940 { lab=Vg}
N 2905 -940 3040 -940 { lab=Vg}
N 3040 -1015 3040 -940 { lab=Vg}
N 3040 -940 3195 -940 { lab=Vg}
N 3510 -1015 3510 -940 { lab=Vg}
N 3195 -940 3510 -940 { lab=Vg}
N 3190 -1015 3190 -940 { lab=Vg}
N 3350 -1015 3350 -940 { lab=Vg}
N 2865 -1045 2865 -1015 { lab=VLX}
N 3000 -1045 3000 -1015 { lab=VLX}
N 3150 -1045 3150 -1015 { lab=VLX}
N 3310 -1045 3310 -1015 { lab=VLX}
N 3470 -1045 3470 -1015 { lab=VLX}
N 2730 -1045 2865 -1045 { lab=VLX}
N 2730 -985 2865 -985 { lab=Vout}
N 2770 -940 2905 -940 { lab=Vg}
N 1975 -1045 2125 -1045 { lab=VLX}
N 2015 -940 2165 -940 { lab=Vg}
N 1975 -985 2125 -985 { lab=Vout}
N 630 -880 765 -880 { lab=VLX}
N 765 -880 915 -880 { lab=VLX}
N 915 -880 1075 -880 { lab=VLX}
N 1075 -880 1235 -880 { lab=VLX}
N 630 -820 765 -820 { lab=Vout}
N 765 -820 915 -820 { lab=Vout}
N 915 -820 1075 -820 { lab=Vout}
N 1075 -820 1235 -820 { lab=Vout}
N 670 -850 670 -775 { lab=Vg}
N 670 -775 805 -775 { lab=Vg}
N 805 -850 805 -775 { lab=Vg}
N 805 -775 960 -775 { lab=Vg}
N 1275 -850 1275 -775 { lab=Vg}
N 960 -775 1275 -775 { lab=Vg}
N 955 -850 955 -775 { lab=Vg}
N 1115 -850 1115 -775 { lab=Vg}
N 630 -880 630 -850 { lab=VLX}
N 765 -880 765 -850 { lab=VLX}
N 915 -880 915 -850 { lab=VLX}
N 1075 -880 1075 -850 { lab=VLX}
N 1235 -880 1235 -850 { lab=VLX}
N 1370 -880 1505 -880 { lab=VLX}
N 1505 -880 1655 -880 { lab=VLX}
N 1655 -880 1815 -880 { lab=VLX}
N 1815 -880 1975 -880 { lab=VLX}
N 1370 -820 1505 -820 { lab=Vout}
N 1505 -820 1655 -820 { lab=Vout}
N 1655 -820 1815 -820 { lab=Vout}
N 1815 -820 1975 -820 { lab=Vout}
N 1410 -850 1410 -775 { lab=Vg}
N 1410 -775 1545 -775 { lab=Vg}
N 1545 -850 1545 -775 { lab=Vg}
N 1545 -775 1700 -775 { lab=Vg}
N 2015 -850 2015 -775 { lab=Vg}
N 1700 -775 2015 -775 { lab=Vg}
N 1695 -850 1695 -775 { lab=Vg}
N 1855 -850 1855 -775 { lab=Vg}
N 1370 -880 1370 -850 { lab=VLX}
N 1505 -880 1505 -850 { lab=VLX}
N 1655 -880 1655 -850 { lab=VLX}
N 1815 -880 1815 -850 { lab=VLX}
N 1975 -880 1975 -850 { lab=VLX}
N 1235 -880 1370 -880 { lab=VLX}
N 1235 -820 1370 -820 { lab=Vout}
N 1275 -775 1410 -775 { lab=Vg}
N 2125 -880 2260 -880 { lab=VLX}
N 2260 -880 2410 -880 { lab=VLX}
N 2410 -880 2570 -880 { lab=VLX}
N 2570 -880 2730 -880 { lab=VLX}
N 2125 -820 2260 -820 { lab=Vout}
N 2260 -820 2410 -820 { lab=Vout}
N 2410 -820 2570 -820 { lab=Vout}
N 2570 -820 2730 -820 { lab=Vout}
N 2165 -850 2165 -775 { lab=Vg}
N 2165 -775 2300 -775 { lab=Vg}
N 2300 -850 2300 -775 { lab=Vg}
N 2300 -775 2455 -775 { lab=Vg}
N 2770 -850 2770 -775 { lab=Vg}
N 2455 -775 2770 -775 { lab=Vg}
N 2450 -850 2450 -775 { lab=Vg}
N 2610 -850 2610 -775 { lab=Vg}
N 2125 -880 2125 -850 { lab=VLX}
N 2260 -880 2260 -850 { lab=VLX}
N 2410 -880 2410 -850 { lab=VLX}
N 2570 -880 2570 -850 { lab=VLX}
N 2730 -880 2730 -850 { lab=VLX}
N 2865 -880 3000 -880 { lab=VLX}
N 3000 -880 3150 -880 { lab=VLX}
N 3150 -880 3310 -880 { lab=VLX}
N 3310 -880 3470 -880 { lab=VLX}
N 2865 -820 3000 -820 { lab=Vout}
N 3000 -820 3150 -820 { lab=Vout}
N 3150 -820 3310 -820 { lab=Vout}
N 3310 -820 3470 -820 { lab=Vout}
N 2905 -850 2905 -775 { lab=Vg}
N 2905 -775 3040 -775 { lab=Vg}
N 3040 -850 3040 -775 { lab=Vg}
N 3040 -775 3195 -775 { lab=Vg}
N 3510 -850 3510 -775 { lab=Vg}
N 3195 -775 3510 -775 { lab=Vg}
N 3190 -850 3190 -775 { lab=Vg}
N 3350 -850 3350 -775 { lab=Vg}
N 2865 -880 2865 -850 { lab=VLX}
N 3000 -880 3000 -850 { lab=VLX}
N 3150 -880 3150 -850 { lab=VLX}
N 3310 -880 3310 -850 { lab=VLX}
N 3470 -880 3470 -850 { lab=VLX}
N 2730 -880 2865 -880 { lab=VLX}
N 2730 -820 2865 -820 { lab=Vout}
N 2770 -775 2905 -775 { lab=Vg}
N 1975 -880 2125 -880 { lab=VLX}
N 2015 -775 2165 -775 { lab=Vg}
N 1975 -820 2125 -820 { lab=Vout}
N 3510 -940 3510 -850 { lab=Vg}
N 385 -1045 630 -1045 { lab=VLX}
N 380 -880 630 -880 { lab=VLX}
N 380 -1045 380 -880 { lab=VLX}
N 380 -1045 385 -1045 { lab=VLX}
N 500 -985 500 -775 { lab=Vout}
N 630 -695 765 -695 { lab=VLX}
N 765 -695 915 -695 { lab=VLX}
N 915 -695 1075 -695 { lab=VLX}
N 1075 -695 1235 -695 { lab=VLX}
N 630 -635 765 -635 { lab=Vout}
N 765 -635 915 -635 { lab=Vout}
N 915 -635 1075 -635 { lab=Vout}
N 1075 -635 1235 -635 { lab=Vout}
N 670 -665 670 -590 { lab=Vg}
N 670 -590 805 -590 { lab=Vg}
N 805 -665 805 -590 { lab=Vg}
N 805 -590 960 -590 { lab=Vg}
N 1275 -665 1275 -590 { lab=Vg}
N 960 -590 1275 -590 { lab=Vg}
N 955 -665 955 -590 { lab=Vg}
N 1115 -665 1115 -590 { lab=Vg}
N 630 -695 630 -665 { lab=VLX}
N 765 -695 765 -665 { lab=VLX}
N 915 -695 915 -665 { lab=VLX}
N 1075 -695 1075 -665 { lab=VLX}
N 1235 -695 1235 -665 { lab=VLX}
N 1370 -695 1505 -695 { lab=VLX}
N 1505 -695 1655 -695 { lab=VLX}
N 1655 -695 1815 -695 { lab=VLX}
N 1815 -695 1975 -695 { lab=VLX}
N 1370 -635 1505 -635 { lab=Vout}
N 1505 -635 1655 -635 { lab=Vout}
N 1655 -635 1815 -635 { lab=Vout}
N 1815 -635 1975 -635 { lab=Vout}
N 1410 -665 1410 -590 { lab=Vg}
N 1410 -590 1545 -590 { lab=Vg}
N 1545 -665 1545 -590 { lab=Vg}
N 1545 -590 1700 -590 { lab=Vg}
N 2015 -665 2015 -590 { lab=Vg}
N 1700 -590 2015 -590 { lab=Vg}
N 1695 -665 1695 -590 { lab=Vg}
N 1855 -665 1855 -590 { lab=Vg}
N 1370 -695 1370 -665 { lab=VLX}
N 1505 -695 1505 -665 { lab=VLX}
N 1655 -695 1655 -665 { lab=VLX}
N 1815 -695 1815 -665 { lab=VLX}
N 1975 -695 1975 -665 { lab=VLX}
N 1235 -695 1370 -695 { lab=VLX}
N 1235 -635 1370 -635 { lab=Vout}
N 1275 -590 1410 -590 { lab=Vg}
N 2125 -695 2260 -695 { lab=VLX}
N 2260 -695 2410 -695 { lab=VLX}
N 2410 -695 2570 -695 { lab=VLX}
N 2570 -695 2730 -695 { lab=VLX}
N 2125 -635 2260 -635 { lab=Vout}
N 2260 -635 2410 -635 { lab=Vout}
N 2410 -635 2570 -635 { lab=Vout}
N 2570 -635 2730 -635 { lab=Vout}
N 2165 -665 2165 -590 { lab=Vg}
N 2165 -590 2300 -590 { lab=Vg}
N 2300 -665 2300 -590 { lab=Vg}
N 2300 -590 2455 -590 { lab=Vg}
N 2770 -665 2770 -590 { lab=Vg}
N 2455 -590 2770 -590 { lab=Vg}
N 2450 -665 2450 -590 { lab=Vg}
N 2610 -665 2610 -590 { lab=Vg}
N 2125 -695 2125 -665 { lab=VLX}
N 2260 -695 2260 -665 { lab=VLX}
N 2410 -695 2410 -665 { lab=VLX}
N 2570 -695 2570 -665 { lab=VLX}
N 2730 -695 2730 -665 { lab=VLX}
N 2865 -695 3000 -695 { lab=VLX}
N 3000 -695 3150 -695 { lab=VLX}
N 3150 -695 3310 -695 { lab=VLX}
N 3310 -695 3470 -695 { lab=VLX}
N 2865 -635 3000 -635 { lab=Vout}
N 3000 -635 3150 -635 { lab=Vout}
N 3150 -635 3310 -635 { lab=Vout}
N 3310 -635 3470 -635 { lab=Vout}
N 2905 -665 2905 -590 { lab=Vg}
N 2905 -590 3040 -590 { lab=Vg}
N 3040 -665 3040 -590 { lab=Vg}
N 3040 -590 3195 -590 { lab=Vg}
N 3510 -665 3510 -590 { lab=Vg}
N 3195 -590 3510 -590 { lab=Vg}
N 3190 -665 3190 -590 { lab=Vg}
N 3350 -665 3350 -590 { lab=Vg}
N 2865 -695 2865 -665 { lab=VLX}
N 3000 -695 3000 -665 { lab=VLX}
N 3150 -695 3150 -665 { lab=VLX}
N 3310 -695 3310 -665 { lab=VLX}
N 3470 -695 3470 -665 { lab=VLX}
N 2730 -695 2865 -695 { lab=VLX}
N 2730 -635 2865 -635 { lab=Vout}
N 2770 -590 2905 -590 { lab=Vg}
N 1975 -695 2125 -695 { lab=VLX}
N 2015 -590 2165 -590 { lab=Vg}
N 1975 -635 2125 -635 { lab=Vout}
N 630 -530 765 -530 { lab=VLX}
N 765 -530 915 -530 { lab=VLX}
N 915 -530 1075 -530 { lab=VLX}
N 1075 -530 1235 -530 { lab=VLX}
N 630 -470 765 -470 { lab=Vout}
N 765 -470 915 -470 { lab=Vout}
N 915 -470 1075 -470 { lab=Vout}
N 1075 -470 1235 -470 { lab=Vout}
N 670 -500 670 -425 { lab=Vg}
N 670 -425 805 -425 { lab=Vg}
N 805 -500 805 -425 { lab=Vg}
N 805 -425 960 -425 { lab=Vg}
N 1275 -500 1275 -425 { lab=Vg}
N 960 -425 1275 -425 { lab=Vg}
N 955 -500 955 -425 { lab=Vg}
N 1115 -500 1115 -425 { lab=Vg}
N 630 -530 630 -500 { lab=VLX}
N 765 -530 765 -500 { lab=VLX}
N 915 -530 915 -500 { lab=VLX}
N 1075 -530 1075 -500 { lab=VLX}
N 1235 -530 1235 -500 { lab=VLX}
N 1370 -530 1505 -530 { lab=VLX}
N 1505 -530 1655 -530 { lab=VLX}
N 1655 -530 1815 -530 { lab=VLX}
N 1815 -530 1975 -530 { lab=VLX}
N 1370 -470 1505 -470 { lab=Vout}
N 1505 -470 1655 -470 { lab=Vout}
N 1655 -470 1815 -470 { lab=Vout}
N 1815 -470 1975 -470 { lab=Vout}
N 1410 -500 1410 -425 { lab=Vg}
N 1410 -425 1545 -425 { lab=Vg}
N 1545 -500 1545 -425 { lab=Vg}
N 1545 -425 1700 -425 { lab=Vg}
N 2015 -500 2015 -425 { lab=Vg}
N 1700 -425 2015 -425 { lab=Vg}
N 1695 -500 1695 -425 { lab=Vg}
N 1855 -500 1855 -425 { lab=Vg}
N 1370 -530 1370 -500 { lab=VLX}
N 1505 -530 1505 -500 { lab=VLX}
N 1655 -530 1655 -500 { lab=VLX}
N 1815 -530 1815 -500 { lab=VLX}
N 1975 -530 1975 -500 { lab=VLX}
N 1235 -530 1370 -530 { lab=VLX}
N 1235 -470 1370 -470 { lab=Vout}
N 1275 -425 1410 -425 { lab=Vg}
N 2125 -530 2260 -530 { lab=VLX}
N 2260 -530 2410 -530 { lab=VLX}
N 2410 -530 2570 -530 { lab=VLX}
N 2570 -530 2730 -530 { lab=VLX}
N 2125 -470 2260 -470 { lab=Vout}
N 2260 -470 2410 -470 { lab=Vout}
N 2410 -470 2570 -470 { lab=Vout}
N 2570 -470 2730 -470 { lab=Vout}
N 2165 -500 2165 -425 { lab=Vg}
N 2165 -425 2300 -425 { lab=Vg}
N 2300 -500 2300 -425 { lab=Vg}
N 2300 -425 2455 -425 { lab=Vg}
N 2770 -500 2770 -425 { lab=Vg}
N 2455 -425 2770 -425 { lab=Vg}
N 2450 -500 2450 -425 { lab=Vg}
N 2610 -500 2610 -425 { lab=Vg}
N 2125 -530 2125 -500 { lab=VLX}
N 2260 -530 2260 -500 { lab=VLX}
N 2410 -530 2410 -500 { lab=VLX}
N 2570 -530 2570 -500 { lab=VLX}
N 2730 -530 2730 -500 { lab=VLX}
N 2865 -530 3000 -530 { lab=VLX}
N 3000 -530 3150 -530 { lab=VLX}
N 3150 -530 3310 -530 { lab=VLX}
N 3310 -530 3470 -530 { lab=VLX}
N 2865 -470 3000 -470 { lab=Vout}
N 3000 -470 3150 -470 { lab=Vout}
N 3150 -470 3310 -470 { lab=Vout}
N 3310 -470 3470 -470 { lab=Vout}
N 2905 -500 2905 -425 { lab=Vg}
N 2905 -425 3040 -425 { lab=Vg}
N 3040 -500 3040 -425 { lab=Vg}
N 3040 -425 3195 -425 { lab=Vg}
N 3510 -500 3510 -425 { lab=Vg}
N 3195 -425 3510 -425 { lab=Vg}
N 3190 -500 3190 -425 { lab=Vg}
N 3350 -500 3350 -425 { lab=Vg}
N 2865 -530 2865 -500 { lab=VLX}
N 3000 -530 3000 -500 { lab=VLX}
N 3150 -530 3150 -500 { lab=VLX}
N 3310 -530 3310 -500 { lab=VLX}
N 3470 -530 3470 -500 { lab=VLX}
N 2730 -530 2865 -530 { lab=VLX}
N 2730 -470 2865 -470 { lab=Vout}
N 2770 -425 2905 -425 { lab=Vg}
N 1975 -530 2125 -530 { lab=VLX}
N 2015 -425 2165 -425 { lab=Vg}
N 1975 -470 2125 -470 { lab=Vout}
N 3510 -590 3510 -500 { lab=Vg}
N 385 -695 630 -695 { lab=VLX}
N 380 -530 630 -530 { lab=VLX}
N 380 -695 380 -530 { lab=VLX}
N 380 -695 385 -695 { lab=VLX}
N 500 -635 500 -425 { lab=Vout}
N 380 -880 380 -690 { lab=VLX}
N 500 -780 500 -630 { lab=Vout}
N 3510 -780 3510 -660 { lab=Vg}
N 630 -375 765 -375 { lab=VLX}
N 765 -375 915 -375 { lab=VLX}
N 915 -375 1075 -375 { lab=VLX}
N 1075 -375 1235 -375 { lab=VLX}
N 630 -315 765 -315 { lab=Vout}
N 765 -315 915 -315 { lab=Vout}
N 915 -315 1075 -315 { lab=Vout}
N 1075 -315 1235 -315 { lab=Vout}
N 670 -345 670 -270 { lab=Vg}
N 670 -270 805 -270 { lab=Vg}
N 805 -345 805 -270 { lab=Vg}
N 805 -270 960 -270 { lab=Vg}
N 1275 -345 1275 -270 { lab=Vg}
N 960 -270 1275 -270 { lab=Vg}
N 955 -345 955 -270 { lab=Vg}
N 1115 -345 1115 -270 { lab=Vg}
N 630 -375 630 -345 { lab=VLX}
N 765 -375 765 -345 { lab=VLX}
N 915 -375 915 -345 { lab=VLX}
N 1075 -375 1075 -345 { lab=VLX}
N 1235 -375 1235 -345 { lab=VLX}
N 1370 -375 1505 -375 { lab=VLX}
N 1505 -375 1655 -375 { lab=VLX}
N 1655 -375 1815 -375 { lab=VLX}
N 1815 -375 1975 -375 { lab=VLX}
N 1370 -315 1505 -315 { lab=Vout}
N 1505 -315 1655 -315 { lab=Vout}
N 1655 -315 1815 -315 { lab=Vout}
N 1815 -315 1975 -315 { lab=Vout}
N 1410 -345 1410 -270 { lab=Vg}
N 1410 -270 1545 -270 { lab=Vg}
N 1545 -345 1545 -270 { lab=Vg}
N 1545 -270 1700 -270 { lab=Vg}
N 2015 -345 2015 -270 { lab=Vg}
N 1700 -270 2015 -270 { lab=Vg}
N 1695 -345 1695 -270 { lab=Vg}
N 1855 -345 1855 -270 { lab=Vg}
N 1370 -375 1370 -345 { lab=VLX}
N 1505 -375 1505 -345 { lab=VLX}
N 1655 -375 1655 -345 { lab=VLX}
N 1815 -375 1815 -345 { lab=VLX}
N 1975 -375 1975 -345 { lab=VLX}
N 1235 -375 1370 -375 { lab=VLX}
N 1235 -315 1370 -315 { lab=Vout}
N 1275 -270 1410 -270 { lab=Vg}
N 2125 -375 2260 -375 { lab=VLX}
N 2260 -375 2410 -375 { lab=VLX}
N 2410 -375 2570 -375 { lab=VLX}
N 2570 -375 2730 -375 { lab=VLX}
N 2125 -315 2260 -315 { lab=Vout}
N 2260 -315 2410 -315 { lab=Vout}
N 2410 -315 2570 -315 { lab=Vout}
N 2570 -315 2730 -315 { lab=Vout}
N 2165 -345 2165 -270 { lab=Vg}
N 2165 -270 2300 -270 { lab=Vg}
N 2300 -345 2300 -270 { lab=Vg}
N 2300 -270 2455 -270 { lab=Vg}
N 2770 -345 2770 -270 { lab=Vg}
N 2455 -270 2770 -270 { lab=Vg}
N 2450 -345 2450 -270 { lab=Vg}
N 2610 -345 2610 -270 { lab=Vg}
N 2125 -375 2125 -345 { lab=VLX}
N 2260 -375 2260 -345 { lab=VLX}
N 2410 -375 2410 -345 { lab=VLX}
N 2570 -375 2570 -345 { lab=VLX}
N 2730 -375 2730 -345 { lab=VLX}
N 2865 -375 3000 -375 { lab=VLX}
N 3000 -375 3150 -375 { lab=VLX}
N 3150 -375 3310 -375 { lab=VLX}
N 3310 -375 3470 -375 { lab=VLX}
N 2865 -315 3000 -315 { lab=Vout}
N 3000 -315 3150 -315 { lab=Vout}
N 3150 -315 3310 -315 { lab=Vout}
N 3310 -315 3470 -315 { lab=Vout}
N 2905 -345 2905 -270 { lab=Vg}
N 2905 -270 3040 -270 { lab=Vg}
N 3040 -345 3040 -270 { lab=Vg}
N 3040 -270 3195 -270 { lab=Vg}
N 3510 -345 3510 -270 { lab=Vg}
N 3195 -270 3510 -270 { lab=Vg}
N 3190 -345 3190 -270 { lab=Vg}
N 3350 -345 3350 -270 { lab=Vg}
N 2865 -375 2865 -345 { lab=VLX}
N 3000 -375 3000 -345 { lab=VLX}
N 3150 -375 3150 -345 { lab=VLX}
N 3310 -375 3310 -345 { lab=VLX}
N 3470 -375 3470 -345 { lab=VLX}
N 2730 -375 2865 -375 { lab=VLX}
N 2730 -315 2865 -315 { lab=Vout}
N 2770 -270 2905 -270 { lab=Vg}
N 1975 -375 2125 -375 { lab=VLX}
N 2015 -270 2165 -270 { lab=Vg}
N 1975 -315 2125 -315 { lab=Vout}
N 630 -210 765 -210 { lab=VLX}
N 765 -210 915 -210 { lab=VLX}
N 915 -210 1075 -210 { lab=VLX}
N 1075 -210 1235 -210 { lab=VLX}
N 630 -150 765 -150 { lab=Vout}
N 765 -150 915 -150 { lab=Vout}
N 915 -150 1075 -150 { lab=Vout}
N 1075 -150 1235 -150 { lab=Vout}
N 670 -180 670 -105 { lab=Vg}
N 670 -105 805 -105 { lab=Vg}
N 805 -180 805 -105 { lab=Vg}
N 805 -105 960 -105 { lab=Vg}
N 1275 -180 1275 -105 { lab=Vg}
N 960 -105 1275 -105 { lab=Vg}
N 955 -180 955 -105 { lab=Vg}
N 1115 -180 1115 -105 { lab=Vg}
N 630 -210 630 -180 { lab=VLX}
N 765 -210 765 -180 { lab=VLX}
N 915 -210 915 -180 { lab=VLX}
N 1075 -210 1075 -180 { lab=VLX}
N 1235 -210 1235 -180 { lab=VLX}
N 1370 -210 1505 -210 { lab=VLX}
N 1505 -210 1655 -210 { lab=VLX}
N 1655 -210 1815 -210 { lab=VLX}
N 1815 -210 1975 -210 { lab=VLX}
N 1370 -150 1505 -150 { lab=Vout}
N 1505 -150 1655 -150 { lab=Vout}
N 1655 -150 1815 -150 { lab=Vout}
N 1815 -150 1975 -150 { lab=Vout}
N 1410 -180 1410 -105 { lab=Vg}
N 1410 -105 1545 -105 { lab=Vg}
N 1545 -180 1545 -105 { lab=Vg}
N 1545 -105 1700 -105 { lab=Vg}
N 2015 -180 2015 -105 { lab=Vg}
N 1700 -105 2015 -105 { lab=Vg}
N 1695 -180 1695 -105 { lab=Vg}
N 1855 -180 1855 -105 { lab=Vg}
N 1370 -210 1370 -180 { lab=VLX}
N 1505 -210 1505 -180 { lab=VLX}
N 1655 -210 1655 -180 { lab=VLX}
N 1815 -210 1815 -180 { lab=VLX}
N 1975 -210 1975 -180 { lab=VLX}
N 1235 -210 1370 -210 { lab=VLX}
N 1235 -150 1370 -150 { lab=Vout}
N 1275 -105 1410 -105 { lab=Vg}
N 2125 -210 2260 -210 { lab=VLX}
N 2260 -210 2410 -210 { lab=VLX}
N 2410 -210 2570 -210 { lab=VLX}
N 2570 -210 2730 -210 { lab=VLX}
N 2125 -150 2260 -150 { lab=Vout}
N 2260 -150 2410 -150 { lab=Vout}
N 2410 -150 2570 -150 { lab=Vout}
N 2570 -150 2730 -150 { lab=Vout}
N 2165 -180 2165 -105 { lab=Vg}
N 2165 -105 2300 -105 { lab=Vg}
N 2300 -180 2300 -105 { lab=Vg}
N 2300 -105 2455 -105 { lab=Vg}
N 2770 -180 2770 -105 { lab=Vg}
N 2455 -105 2770 -105 { lab=Vg}
N 2450 -180 2450 -105 { lab=Vg}
N 2610 -180 2610 -105 { lab=Vg}
N 2125 -210 2125 -180 { lab=VLX}
N 2260 -210 2260 -180 { lab=VLX}
N 2410 -210 2410 -180 { lab=VLX}
N 2570 -210 2570 -180 { lab=VLX}
N 2730 -210 2730 -180 { lab=VLX}
N 2865 -210 3000 -210 { lab=VLX}
N 3000 -210 3150 -210 { lab=VLX}
N 3150 -210 3310 -210 { lab=VLX}
N 3310 -210 3470 -210 { lab=VLX}
N 2865 -150 3000 -150 { lab=Vout}
N 3000 -150 3150 -150 { lab=Vout}
N 3150 -150 3310 -150 { lab=Vout}
N 3310 -150 3470 -150 { lab=Vout}
N 2905 -180 2905 -105 { lab=Vg}
N 2905 -105 3040 -105 { lab=Vg}
N 3040 -180 3040 -105 { lab=Vg}
N 3040 -105 3195 -105 { lab=Vg}
N 3510 -180 3510 -105 { lab=Vg}
N 3195 -105 3510 -105 { lab=Vg}
N 3190 -180 3190 -105 { lab=Vg}
N 3350 -180 3350 -105 { lab=Vg}
N 2865 -210 2865 -180 { lab=VLX}
N 3000 -210 3000 -180 { lab=VLX}
N 3150 -210 3150 -180 { lab=VLX}
N 3310 -210 3310 -180 { lab=VLX}
N 3470 -210 3470 -180 { lab=VLX}
N 2730 -210 2865 -210 { lab=VLX}
N 2730 -150 2865 -150 { lab=Vout}
N 2770 -105 2905 -105 { lab=Vg}
N 1975 -210 2125 -210 { lab=VLX}
N 2015 -105 2165 -105 { lab=Vg}
N 1975 -150 2125 -150 { lab=Vout}
N 3510 -270 3510 -180 { lab=Vg}
N 385 -375 630 -375 { lab=VLX}
N 380 -210 630 -210 { lab=VLX}
N 380 -375 380 -210 { lab=VLX}
N 380 -375 385 -375 { lab=VLX}
N 500 -315 500 -105 { lab=Vout}
N 630 -25 765 -25 { lab=VLX}
N 765 -25 915 -25 { lab=VLX}
N 915 -25 1075 -25 { lab=VLX}
N 1075 -25 1235 -25 { lab=VLX}
N 630 35 765 35 { lab=Vout}
N 765 35 915 35 { lab=Vout}
N 915 35 1075 35 { lab=Vout}
N 1075 35 1235 35 { lab=Vout}
N 670 5 670 80 { lab=Vg}
N 670 80 805 80 { lab=Vg}
N 805 5 805 80 { lab=Vg}
N 805 80 960 80 { lab=Vg}
N 1275 5 1275 80 { lab=Vg}
N 960 80 1275 80 { lab=Vg}
N 955 5 955 80 { lab=Vg}
N 1115 5 1115 80 { lab=Vg}
N 630 -25 630 5 { lab=VLX}
N 765 -25 765 5 { lab=VLX}
N 915 -25 915 5 { lab=VLX}
N 1075 -25 1075 5 { lab=VLX}
N 1235 -25 1235 5 { lab=VLX}
N 1370 -25 1505 -25 { lab=VLX}
N 1505 -25 1655 -25 { lab=VLX}
N 1655 -25 1815 -25 { lab=VLX}
N 1815 -25 1975 -25 { lab=VLX}
N 1370 35 1505 35 { lab=Vout}
N 1505 35 1655 35 { lab=Vout}
N 1655 35 1815 35 { lab=Vout}
N 1815 35 1975 35 { lab=Vout}
N 1410 5 1410 80 { lab=Vg}
N 1410 80 1545 80 { lab=Vg}
N 1545 5 1545 80 { lab=Vg}
N 1545 80 1700 80 { lab=Vg}
N 2015 5 2015 80 { lab=Vg}
N 1700 80 2015 80 { lab=Vg}
N 1695 5 1695 80 { lab=Vg}
N 1855 5 1855 80 { lab=Vg}
N 1370 -25 1370 5 { lab=VLX}
N 1505 -25 1505 5 { lab=VLX}
N 1655 -25 1655 5 { lab=VLX}
N 1815 -25 1815 5 { lab=VLX}
N 1975 -25 1975 5 { lab=VLX}
N 1235 -25 1370 -25 { lab=VLX}
N 1235 35 1370 35 { lab=Vout}
N 1275 80 1410 80 { lab=Vg}
N 2125 -25 2260 -25 { lab=VLX}
N 2260 -25 2410 -25 { lab=VLX}
N 2410 -25 2570 -25 { lab=VLX}
N 2570 -25 2730 -25 { lab=VLX}
N 2125 35 2260 35 { lab=Vout}
N 2260 35 2410 35 { lab=Vout}
N 2410 35 2570 35 { lab=Vout}
N 2570 35 2730 35 { lab=Vout}
N 2165 5 2165 80 { lab=Vg}
N 2165 80 2300 80 { lab=Vg}
N 2300 5 2300 80 { lab=Vg}
N 2300 80 2455 80 { lab=Vg}
N 2770 5 2770 80 { lab=Vg}
N 2455 80 2770 80 { lab=Vg}
N 2450 5 2450 80 { lab=Vg}
N 2610 5 2610 80 { lab=Vg}
N 2125 -25 2125 5 { lab=VLX}
N 2260 -25 2260 5 { lab=VLX}
N 2410 -25 2410 5 { lab=VLX}
N 2570 -25 2570 5 { lab=VLX}
N 2730 -25 2730 5 { lab=VLX}
N 2865 -25 3000 -25 { lab=VLX}
N 3000 -25 3150 -25 { lab=VLX}
N 3150 -25 3310 -25 { lab=VLX}
N 3310 -25 3470 -25 { lab=VLX}
N 2865 35 3000 35 { lab=Vout}
N 3000 35 3150 35 { lab=Vout}
N 3150 35 3310 35 { lab=Vout}
N 3310 35 3470 35 { lab=Vout}
N 2905 5 2905 80 { lab=Vg}
N 2905 80 3040 80 { lab=Vg}
N 3040 5 3040 80 { lab=Vg}
N 3040 80 3195 80 { lab=Vg}
N 3510 5 3510 80 { lab=Vg}
N 3195 80 3510 80 { lab=Vg}
N 3190 5 3190 80 { lab=Vg}
N 3350 5 3350 80 { lab=Vg}
N 2865 -25 2865 5 { lab=VLX}
N 3000 -25 3000 5 { lab=VLX}
N 3150 -25 3150 5 { lab=VLX}
N 3310 -25 3310 5 { lab=VLX}
N 3470 -25 3470 5 { lab=VLX}
N 2730 -25 2865 -25 { lab=VLX}
N 2730 35 2865 35 { lab=Vout}
N 2770 80 2905 80 { lab=Vg}
N 1975 -25 2125 -25 { lab=VLX}
N 2015 80 2165 80 { lab=Vg}
N 1975 35 2125 35 { lab=Vout}
N 630 140 765 140 { lab=VLX}
N 765 140 915 140 { lab=VLX}
N 915 140 1075 140 { lab=VLX}
N 1075 140 1235 140 { lab=VLX}
N 630 200 765 200 { lab=Vout}
N 765 200 915 200 { lab=Vout}
N 915 200 1075 200 { lab=Vout}
N 1075 200 1235 200 { lab=Vout}
N 670 170 670 245 { lab=Vg}
N 670 245 805 245 { lab=Vg}
N 805 170 805 245 { lab=Vg}
N 805 245 960 245 { lab=Vg}
N 1275 170 1275 245 { lab=Vg}
N 960 245 1275 245 { lab=Vg}
N 955 170 955 245 { lab=Vg}
N 1115 170 1115 245 { lab=Vg}
N 630 140 630 170 { lab=VLX}
N 765 140 765 170 { lab=VLX}
N 915 140 915 170 { lab=VLX}
N 1075 140 1075 170 { lab=VLX}
N 1235 140 1235 170 { lab=VLX}
N 1370 140 1505 140 { lab=VLX}
N 1505 140 1655 140 { lab=VLX}
N 1655 140 1815 140 { lab=VLX}
N 1815 140 1975 140 { lab=VLX}
N 1370 200 1505 200 { lab=Vout}
N 1505 200 1655 200 { lab=Vout}
N 1655 200 1815 200 { lab=Vout}
N 1815 200 1975 200 { lab=Vout}
N 1410 170 1410 245 { lab=Vg}
N 1410 245 1545 245 { lab=Vg}
N 1545 170 1545 245 { lab=Vg}
N 1545 245 1700 245 { lab=Vg}
N 2015 170 2015 245 { lab=Vg}
N 1700 245 2015 245 { lab=Vg}
N 1695 170 1695 245 { lab=Vg}
N 1855 170 1855 245 { lab=Vg}
N 1370 140 1370 170 { lab=VLX}
N 1505 140 1505 170 { lab=VLX}
N 1655 140 1655 170 { lab=VLX}
N 1815 140 1815 170 { lab=VLX}
N 1975 140 1975 170 { lab=VLX}
N 1235 140 1370 140 { lab=VLX}
N 1235 200 1370 200 { lab=Vout}
N 1275 245 1410 245 { lab=Vg}
N 2125 140 2260 140 { lab=VLX}
N 2260 140 2410 140 { lab=VLX}
N 2410 140 2570 140 { lab=VLX}
N 2570 140 2730 140 { lab=VLX}
N 2125 200 2260 200 { lab=Vout}
N 2260 200 2410 200 { lab=Vout}
N 2410 200 2570 200 { lab=Vout}
N 2570 200 2730 200 { lab=Vout}
N 2165 170 2165 245 { lab=Vg}
N 2165 245 2300 245 { lab=Vg}
N 2300 170 2300 245 { lab=Vg}
N 2300 245 2455 245 { lab=Vg}
N 2770 170 2770 245 { lab=Vg}
N 2455 245 2770 245 { lab=Vg}
N 2450 170 2450 245 { lab=Vg}
N 2610 170 2610 245 { lab=Vg}
N 2125 140 2125 170 { lab=VLX}
N 2260 140 2260 170 { lab=VLX}
N 2410 140 2410 170 { lab=VLX}
N 2570 140 2570 170 { lab=VLX}
N 2730 140 2730 170 { lab=VLX}
N 2865 140 3000 140 { lab=VLX}
N 3000 140 3150 140 { lab=VLX}
N 3150 140 3310 140 { lab=VLX}
N 3310 140 3470 140 { lab=VLX}
N 2865 200 3000 200 { lab=Vout}
N 3000 200 3150 200 { lab=Vout}
N 3150 200 3310 200 { lab=Vout}
N 3310 200 3470 200 { lab=Vout}
N 2905 170 2905 245 { lab=Vg}
N 2905 245 3040 245 { lab=Vg}
N 3040 170 3040 245 { lab=Vg}
N 3040 245 3195 245 { lab=Vg}
N 3510 170 3510 245 { lab=Vg}
N 3195 245 3510 245 { lab=Vg}
N 3190 170 3190 245 { lab=Vg}
N 3350 170 3350 245 { lab=Vg}
N 2865 140 2865 170 { lab=VLX}
N 3000 140 3000 170 { lab=VLX}
N 3150 140 3150 170 { lab=VLX}
N 3310 140 3310 170 { lab=VLX}
N 3470 140 3470 170 { lab=VLX}
N 2730 140 2865 140 { lab=VLX}
N 2730 200 2865 200 { lab=Vout}
N 2770 245 2905 245 { lab=Vg}
N 1975 140 2125 140 { lab=VLX}
N 2015 245 2165 245 { lab=Vg}
N 1975 200 2125 200 { lab=Vout}
N 3510 80 3510 170 { lab=Vg}
N 385 -25 630 -25 { lab=VLX}
N 380 140 630 140 { lab=VLX}
N 380 -25 380 140 { lab=VLX}
N 380 -25 385 -25 { lab=VLX}
N 500 35 630 35 { lab=Vout}
N 500 35 500 245 { lab=Vout}
N 380 -210 380 -20 { lab=VLX}
N 500 -110 500 40 { lab=Vout}
N 3510 -110 3510 10 { lab=Vg}
N 380 -530 380 -370 { lab=VLX}
N 500 -430 500 -310 { lab=Vout}
N 3510 -420 3510 -350 { lab=Vg}
N 3510 -430 3510 -420 { lab=Vg}
N 3510 -1180 3510 -1010 { lab=Vg}
N 500 -1180 500 -970 { lab=Vout}
N 380 -1280 380 -1040 { lab=VLX}
N 630 395 765 395 { lab=VLX}
N 765 395 915 395 { lab=VLX}
N 915 395 1075 395 { lab=VLX}
N 1075 395 1235 395 { lab=VLX}
N 630 455 765 455 { lab=Vout}
N 765 455 915 455 { lab=Vout}
N 915 455 1075 455 { lab=Vout}
N 1075 455 1235 455 { lab=Vout}
N 670 425 670 500 { lab=Vg}
N 670 500 805 500 { lab=Vg}
N 805 425 805 500 { lab=Vg}
N 805 500 960 500 { lab=Vg}
N 1275 425 1275 500 { lab=Vg}
N 960 500 1275 500 { lab=Vg}
N 955 425 955 500 { lab=Vg}
N 1115 425 1115 500 { lab=Vg}
N 630 395 630 425 { lab=VLX}
N 765 395 765 425 { lab=VLX}
N 915 395 915 425 { lab=VLX}
N 1075 395 1075 425 { lab=VLX}
N 1235 395 1235 425 { lab=VLX}
N 1370 395 1505 395 { lab=VLX}
N 1505 395 1655 395 { lab=VLX}
N 1655 395 1815 395 { lab=VLX}
N 1815 395 1975 395 { lab=VLX}
N 1370 455 1505 455 { lab=Vout}
N 1505 455 1655 455 { lab=Vout}
N 1655 455 1815 455 { lab=Vout}
N 1815 455 1975 455 { lab=Vout}
N 1410 425 1410 500 { lab=Vg}
N 1410 500 1545 500 { lab=Vg}
N 1545 425 1545 500 { lab=Vg}
N 1545 500 1700 500 { lab=Vg}
N 2015 425 2015 500 { lab=Vg}
N 1700 500 2015 500 { lab=Vg}
N 1695 425 1695 500 { lab=Vg}
N 1855 425 1855 500 { lab=Vg}
N 1370 395 1370 425 { lab=VLX}
N 1505 395 1505 425 { lab=VLX}
N 1655 395 1655 425 { lab=VLX}
N 1815 395 1815 425 { lab=VLX}
N 1975 395 1975 425 { lab=VLX}
N 1235 395 1370 395 { lab=VLX}
N 1235 455 1370 455 { lab=Vout}
N 1275 500 1410 500 { lab=Vg}
N 2125 395 2260 395 { lab=VLX}
N 2260 395 2410 395 { lab=VLX}
N 2410 395 2570 395 { lab=VLX}
N 2570 395 2730 395 { lab=VLX}
N 2125 455 2260 455 { lab=Vout}
N 2260 455 2410 455 { lab=Vout}
N 2410 455 2570 455 { lab=Vout}
N 2570 455 2730 455 { lab=Vout}
N 2165 425 2165 500 { lab=Vg}
N 2165 500 2300 500 { lab=Vg}
N 2300 425 2300 500 { lab=Vg}
N 2300 500 2455 500 { lab=Vg}
N 2770 425 2770 500 { lab=Vg}
N 2455 500 2770 500 { lab=Vg}
N 2450 425 2450 500 { lab=Vg}
N 2610 425 2610 500 { lab=Vg}
N 2125 395 2125 425 { lab=VLX}
N 2260 395 2260 425 { lab=VLX}
N 2410 395 2410 425 { lab=VLX}
N 2570 395 2570 425 { lab=VLX}
N 2730 395 2730 425 { lab=VLX}
N 2865 395 3000 395 { lab=VLX}
N 3000 395 3150 395 { lab=VLX}
N 3150 395 3310 395 { lab=VLX}
N 3310 395 3470 395 { lab=VLX}
N 2865 455 3000 455 { lab=Vout}
N 3000 455 3150 455 { lab=Vout}
N 3150 455 3310 455 { lab=Vout}
N 3310 455 3470 455 { lab=Vout}
N 2905 425 2905 500 { lab=Vg}
N 2905 500 3040 500 { lab=Vg}
N 3040 425 3040 500 { lab=Vg}
N 3040 500 3195 500 { lab=Vg}
N 3510 425 3510 500 { lab=Vg}
N 3195 500 3510 500 { lab=Vg}
N 3190 425 3190 500 { lab=Vg}
N 3350 425 3350 500 { lab=Vg}
N 2865 395 2865 425 { lab=VLX}
N 3000 395 3000 425 { lab=VLX}
N 3150 395 3150 425 { lab=VLX}
N 3310 395 3310 425 { lab=VLX}
N 3470 395 3470 425 { lab=VLX}
N 2730 395 2865 395 { lab=VLX}
N 2730 455 2865 455 { lab=Vout}
N 2770 500 2905 500 { lab=Vg}
N 1975 395 2125 395 { lab=VLX}
N 2015 500 2165 500 { lab=Vg}
N 1975 455 2125 455 { lab=Vout}
N 630 560 765 560 { lab=VLX}
N 765 560 915 560 { lab=VLX}
N 915 560 1075 560 { lab=VLX}
N 1075 560 1235 560 { lab=VLX}
N 630 620 765 620 { lab=Vout}
N 765 620 915 620 { lab=Vout}
N 915 620 1075 620 { lab=Vout}
N 1075 620 1235 620 { lab=Vout}
N 670 590 670 665 { lab=Vg}
N 670 665 805 665 { lab=Vg}
N 805 590 805 665 { lab=Vg}
N 805 665 960 665 { lab=Vg}
N 1275 590 1275 665 { lab=Vg}
N 960 665 1275 665 { lab=Vg}
N 955 590 955 665 { lab=Vg}
N 1115 590 1115 665 { lab=Vg}
N 630 560 630 590 { lab=VLX}
N 765 560 765 590 { lab=VLX}
N 915 560 915 590 { lab=VLX}
N 1075 560 1075 590 { lab=VLX}
N 1235 560 1235 590 { lab=VLX}
N 1370 560 1505 560 { lab=VLX}
N 1505 560 1655 560 { lab=VLX}
N 1655 560 1815 560 { lab=VLX}
N 1815 560 1975 560 { lab=VLX}
N 1370 620 1505 620 { lab=Vout}
N 1505 620 1655 620 { lab=Vout}
N 1655 620 1815 620 { lab=Vout}
N 1815 620 1975 620 { lab=Vout}
N 1410 590 1410 665 { lab=Vg}
N 1410 665 1545 665 { lab=Vg}
N 1545 590 1545 665 { lab=Vg}
N 1545 665 1700 665 { lab=Vg}
N 2015 590 2015 665 { lab=Vg}
N 1700 665 2015 665 { lab=Vg}
N 1695 590 1695 665 { lab=Vg}
N 1855 590 1855 665 { lab=Vg}
N 1370 560 1370 590 { lab=VLX}
N 1505 560 1505 590 { lab=VLX}
N 1655 560 1655 590 { lab=VLX}
N 1815 560 1815 590 { lab=VLX}
N 1975 560 1975 590 { lab=VLX}
N 1235 560 1370 560 { lab=VLX}
N 1235 620 1370 620 { lab=Vout}
N 1275 665 1410 665 { lab=Vg}
N 2125 560 2260 560 { lab=VLX}
N 2260 560 2410 560 { lab=VLX}
N 2410 560 2570 560 { lab=VLX}
N 2570 560 2730 560 { lab=VLX}
N 2125 620 2260 620 { lab=Vout}
N 2260 620 2410 620 { lab=Vout}
N 2410 620 2570 620 { lab=Vout}
N 2570 620 2730 620 { lab=Vout}
N 2165 590 2165 665 { lab=Vg}
N 2165 665 2300 665 { lab=Vg}
N 2300 590 2300 665 { lab=Vg}
N 2300 665 2455 665 { lab=Vg}
N 2770 590 2770 665 { lab=Vg}
N 2455 665 2770 665 { lab=Vg}
N 2450 590 2450 665 { lab=Vg}
N 2610 590 2610 665 { lab=Vg}
N 2125 560 2125 590 { lab=VLX}
N 2260 560 2260 590 { lab=VLX}
N 2410 560 2410 590 { lab=VLX}
N 2570 560 2570 590 { lab=VLX}
N 2730 560 2730 590 { lab=VLX}
N 2865 560 3000 560 { lab=VLX}
N 3000 560 3150 560 { lab=VLX}
N 3150 560 3310 560 { lab=VLX}
N 3310 560 3470 560 { lab=VLX}
N 2865 620 3000 620 { lab=Vout}
N 3000 620 3150 620 { lab=Vout}
N 3150 620 3310 620 { lab=Vout}
N 3310 620 3470 620 { lab=Vout}
N 2905 590 2905 665 { lab=Vg}
N 2905 665 3040 665 { lab=Vg}
N 3040 590 3040 665 { lab=Vg}
N 3040 665 3195 665 { lab=Vg}
N 3510 590 3510 665 { lab=Vg}
N 3195 665 3510 665 { lab=Vg}
N 3190 590 3190 665 { lab=Vg}
N 3350 590 3350 665 { lab=Vg}
N 2865 560 2865 590 { lab=VLX}
N 3000 560 3000 590 { lab=VLX}
N 3150 560 3150 590 { lab=VLX}
N 3310 560 3310 590 { lab=VLX}
N 3470 560 3470 590 { lab=VLX}
N 2730 560 2865 560 { lab=VLX}
N 2730 620 2865 620 { lab=Vout}
N 2770 665 2905 665 { lab=Vg}
N 1975 560 2125 560 { lab=VLX}
N 2015 665 2165 665 { lab=Vg}
N 1975 620 2125 620 { lab=Vout}
N 3510 500 3510 590 { lab=Vg}
N 385 395 630 395 { lab=VLX}
N 380 560 630 560 { lab=VLX}
N 380 395 380 560 { lab=VLX}
N 380 395 385 395 { lab=VLX}
N 500 455 630 455 { lab=Vout}
N 500 455 500 665 { lab=Vout}
N 630 745 765 745 { lab=VLX}
N 765 745 915 745 { lab=VLX}
N 915 745 1075 745 { lab=VLX}
N 1075 745 1235 745 { lab=VLX}
N 630 805 765 805 { lab=Vout}
N 765 805 915 805 { lab=Vout}
N 915 805 1075 805 { lab=Vout}
N 1075 805 1235 805 { lab=Vout}
N 670 775 670 850 { lab=Vg}
N 670 850 805 850 { lab=Vg}
N 805 775 805 850 { lab=Vg}
N 805 850 960 850 { lab=Vg}
N 1275 775 1275 850 { lab=Vg}
N 960 850 1275 850 { lab=Vg}
N 955 775 955 850 { lab=Vg}
N 1115 775 1115 850 { lab=Vg}
N 630 745 630 775 { lab=VLX}
N 765 745 765 775 { lab=VLX}
N 915 745 915 775 { lab=VLX}
N 1075 745 1075 775 { lab=VLX}
N 1235 745 1235 775 { lab=VLX}
N 1370 745 1505 745 { lab=VLX}
N 1505 745 1655 745 { lab=VLX}
N 1655 745 1815 745 { lab=VLX}
N 1815 745 1975 745 { lab=VLX}
N 1370 805 1505 805 { lab=Vout}
N 1505 805 1655 805 { lab=Vout}
N 1655 805 1815 805 { lab=Vout}
N 1815 805 1975 805 { lab=Vout}
N 1410 775 1410 850 { lab=Vg}
N 1410 850 1545 850 { lab=Vg}
N 1545 775 1545 850 { lab=Vg}
N 1545 850 1700 850 { lab=Vg}
N 2015 775 2015 850 { lab=Vg}
N 1700 850 2015 850 { lab=Vg}
N 1695 775 1695 850 { lab=Vg}
N 1855 775 1855 850 { lab=Vg}
N 1370 745 1370 775 { lab=VLX}
N 1505 745 1505 775 { lab=VLX}
N 1655 745 1655 775 { lab=VLX}
N 1815 745 1815 775 { lab=VLX}
N 1975 745 1975 775 { lab=VLX}
N 1235 745 1370 745 { lab=VLX}
N 1235 805 1370 805 { lab=Vout}
N 1275 850 1410 850 { lab=Vg}
N 2125 745 2260 745 { lab=VLX}
N 2260 745 2410 745 { lab=VLX}
N 2410 745 2570 745 { lab=VLX}
N 2570 745 2730 745 { lab=VLX}
N 2125 805 2260 805 { lab=Vout}
N 2260 805 2410 805 { lab=Vout}
N 2410 805 2570 805 { lab=Vout}
N 2570 805 2730 805 { lab=Vout}
N 2165 775 2165 850 { lab=Vg}
N 2165 850 2300 850 { lab=Vg}
N 2300 775 2300 850 { lab=Vg}
N 2300 850 2455 850 { lab=Vg}
N 2770 775 2770 850 { lab=Vg}
N 2455 850 2770 850 { lab=Vg}
N 2450 775 2450 850 { lab=Vg}
N 2610 775 2610 850 { lab=Vg}
N 2125 745 2125 775 { lab=VLX}
N 2260 745 2260 775 { lab=VLX}
N 2410 745 2410 775 { lab=VLX}
N 2570 745 2570 775 { lab=VLX}
N 2730 745 2730 775 { lab=VLX}
N 2865 745 3000 745 { lab=VLX}
N 3000 745 3150 745 { lab=VLX}
N 3150 745 3310 745 { lab=VLX}
N 3310 745 3470 745 { lab=VLX}
N 2865 805 3000 805 { lab=Vout}
N 3000 805 3150 805 { lab=Vout}
N 3150 805 3310 805 { lab=Vout}
N 3310 805 3470 805 { lab=Vout}
N 2905 775 2905 850 { lab=Vg}
N 2905 850 3040 850 { lab=Vg}
N 3040 775 3040 850 { lab=Vg}
N 3040 850 3195 850 { lab=Vg}
N 3510 775 3510 850 { lab=Vg}
N 3195 850 3510 850 { lab=Vg}
N 3190 775 3190 850 { lab=Vg}
N 3350 775 3350 850 { lab=Vg}
N 2865 745 2865 775 { lab=VLX}
N 3000 745 3000 775 { lab=VLX}
N 3150 745 3150 775 { lab=VLX}
N 3310 745 3310 775 { lab=VLX}
N 3470 745 3470 775 { lab=VLX}
N 2730 745 2865 745 { lab=VLX}
N 2730 805 2865 805 { lab=Vout}
N 2770 850 2905 850 { lab=Vg}
N 1975 745 2125 745 { lab=VLX}
N 2015 850 2165 850 { lab=Vg}
N 1975 805 2125 805 { lab=Vout}
N 630 910 765 910 { lab=VLX}
N 765 910 915 910 { lab=VLX}
N 915 910 1075 910 { lab=VLX}
N 1075 910 1235 910 { lab=VLX}
N 630 970 765 970 { lab=Vout}
N 765 970 915 970 { lab=Vout}
N 915 970 1075 970 { lab=Vout}
N 1075 970 1235 970 { lab=Vout}
N 670 940 670 1015 { lab=Vg}
N 670 1015 805 1015 { lab=Vg}
N 805 940 805 1015 { lab=Vg}
N 805 1015 960 1015 { lab=Vg}
N 1275 940 1275 1015 { lab=Vg}
N 960 1015 1275 1015 { lab=Vg}
N 955 940 955 1015 { lab=Vg}
N 1115 940 1115 1015 { lab=Vg}
N 630 910 630 940 { lab=VLX}
N 765 910 765 940 { lab=VLX}
N 915 910 915 940 { lab=VLX}
N 1075 910 1075 940 { lab=VLX}
N 1235 910 1235 940 { lab=VLX}
N 1370 910 1505 910 { lab=VLX}
N 1505 910 1655 910 { lab=VLX}
N 1655 910 1815 910 { lab=VLX}
N 1815 910 1975 910 { lab=VLX}
N 1370 970 1505 970 { lab=Vout}
N 1505 970 1655 970 { lab=Vout}
N 1655 970 1815 970 { lab=Vout}
N 1815 970 1975 970 { lab=Vout}
N 1410 940 1410 1015 { lab=Vg}
N 1410 1015 1545 1015 { lab=Vg}
N 1545 940 1545 1015 { lab=Vg}
N 1545 1015 1700 1015 { lab=Vg}
N 2015 940 2015 1015 { lab=Vg}
N 1700 1015 2015 1015 { lab=Vg}
N 1695 940 1695 1015 { lab=Vg}
N 1855 940 1855 1015 { lab=Vg}
N 1370 910 1370 940 { lab=VLX}
N 1505 910 1505 940 { lab=VLX}
N 1655 910 1655 940 { lab=VLX}
N 1815 910 1815 940 { lab=VLX}
N 1975 910 1975 940 { lab=VLX}
N 1235 910 1370 910 { lab=VLX}
N 1235 970 1370 970 { lab=Vout}
N 1275 1015 1410 1015 { lab=Vg}
N 2125 910 2260 910 { lab=VLX}
N 2260 910 2410 910 { lab=VLX}
N 2410 910 2570 910 { lab=VLX}
N 2570 910 2730 910 { lab=VLX}
N 2125 970 2260 970 { lab=Vout}
N 2260 970 2410 970 { lab=Vout}
N 2410 970 2570 970 { lab=Vout}
N 2570 970 2730 970 { lab=Vout}
N 2165 940 2165 1015 { lab=Vg}
N 2165 1015 2300 1015 { lab=Vg}
N 2300 940 2300 1015 { lab=Vg}
N 2300 1015 2455 1015 { lab=Vg}
N 2770 940 2770 1015 { lab=Vg}
N 2455 1015 2770 1015 { lab=Vg}
N 2450 940 2450 1015 { lab=Vg}
N 2610 940 2610 1015 { lab=Vg}
N 2125 910 2125 940 { lab=VLX}
N 2260 910 2260 940 { lab=VLX}
N 2410 910 2410 940 { lab=VLX}
N 2570 910 2570 940 { lab=VLX}
N 2730 910 2730 940 { lab=VLX}
N 2865 910 3000 910 { lab=VLX}
N 3000 910 3150 910 { lab=VLX}
N 3150 910 3310 910 { lab=VLX}
N 3310 910 3470 910 { lab=VLX}
N 2865 970 3000 970 { lab=Vout}
N 3000 970 3150 970 { lab=Vout}
N 3150 970 3310 970 { lab=Vout}
N 3310 970 3470 970 { lab=Vout}
N 2905 940 2905 1015 { lab=Vg}
N 2905 1015 3040 1015 { lab=Vg}
N 3040 940 3040 1015 { lab=Vg}
N 3040 1015 3195 1015 { lab=Vg}
N 3510 940 3510 1015 { lab=Vg}
N 3195 1015 3510 1015 { lab=Vg}
N 3190 940 3190 1015 { lab=Vg}
N 3350 940 3350 1015 { lab=Vg}
N 2865 910 2865 940 { lab=VLX}
N 3000 910 3000 940 { lab=VLX}
N 3150 910 3150 940 { lab=VLX}
N 3310 910 3310 940 { lab=VLX}
N 3470 910 3470 940 { lab=VLX}
N 2730 910 2865 910 { lab=VLX}
N 2730 970 2865 970 { lab=Vout}
N 2770 1015 2905 1015 { lab=Vg}
N 1975 910 2125 910 { lab=VLX}
N 2015 1015 2165 1015 { lab=Vg}
N 1975 970 2125 970 { lab=Vout}
N 3510 850 3510 940 { lab=Vg}
N 385 745 630 745 { lab=VLX}
N 380 910 630 910 { lab=VLX}
N 380 745 380 910 { lab=VLX}
N 380 745 385 745 { lab=VLX}
N 500 805 630 805 { lab=Vout}
N 500 805 500 1015 { lab=Vout}
N 380 560 380 750 { lab=VLX}
N 500 660 500 810 { lab=Vout}
N 3510 660 3510 780 { lab=Vg}
N 630 1065 765 1065 { lab=VLX}
N 765 1065 915 1065 { lab=VLX}
N 915 1065 1075 1065 { lab=VLX}
N 1075 1065 1235 1065 { lab=VLX}
N 630 1125 765 1125 { lab=Vout}
N 765 1125 915 1125 { lab=Vout}
N 915 1125 1075 1125 { lab=Vout}
N 1075 1125 1235 1125 { lab=Vout}
N 670 1095 670 1170 { lab=Vg}
N 670 1170 805 1170 { lab=Vg}
N 805 1095 805 1170 { lab=Vg}
N 805 1170 960 1170 { lab=Vg}
N 1275 1095 1275 1170 { lab=Vg}
N 960 1170 1275 1170 { lab=Vg}
N 955 1095 955 1170 { lab=Vg}
N 1115 1095 1115 1170 { lab=Vg}
N 630 1065 630 1095 { lab=VLX}
N 765 1065 765 1095 { lab=VLX}
N 915 1065 915 1095 { lab=VLX}
N 1075 1065 1075 1095 { lab=VLX}
N 1235 1065 1235 1095 { lab=VLX}
N 1370 1065 1505 1065 { lab=VLX}
N 1505 1065 1655 1065 { lab=VLX}
N 1655 1065 1815 1065 { lab=VLX}
N 1815 1065 1975 1065 { lab=VLX}
N 1370 1125 1505 1125 { lab=Vout}
N 1505 1125 1655 1125 { lab=Vout}
N 1655 1125 1815 1125 { lab=Vout}
N 1815 1125 1975 1125 { lab=Vout}
N 1410 1095 1410 1170 { lab=Vg}
N 1410 1170 1545 1170 { lab=Vg}
N 1545 1095 1545 1170 { lab=Vg}
N 1545 1170 1700 1170 { lab=Vg}
N 2015 1095 2015 1170 { lab=Vg}
N 1700 1170 2015 1170 { lab=Vg}
N 1695 1095 1695 1170 { lab=Vg}
N 1855 1095 1855 1170 { lab=Vg}
N 1370 1065 1370 1095 { lab=VLX}
N 1505 1065 1505 1095 { lab=VLX}
N 1655 1065 1655 1095 { lab=VLX}
N 1815 1065 1815 1095 { lab=VLX}
N 1975 1065 1975 1095 { lab=VLX}
N 1235 1065 1370 1065 { lab=VLX}
N 1235 1125 1370 1125 { lab=Vout}
N 1275 1170 1410 1170 { lab=Vg}
N 2125 1065 2260 1065 { lab=VLX}
N 2260 1065 2410 1065 { lab=VLX}
N 2410 1065 2570 1065 { lab=VLX}
N 2570 1065 2730 1065 { lab=VLX}
N 2125 1125 2260 1125 { lab=Vout}
N 2260 1125 2410 1125 { lab=Vout}
N 2410 1125 2570 1125 { lab=Vout}
N 2570 1125 2730 1125 { lab=Vout}
N 2165 1095 2165 1170 { lab=Vg}
N 2165 1170 2300 1170 { lab=Vg}
N 2300 1095 2300 1170 { lab=Vg}
N 2300 1170 2455 1170 { lab=Vg}
N 2770 1095 2770 1170 { lab=Vg}
N 2455 1170 2770 1170 { lab=Vg}
N 2450 1095 2450 1170 { lab=Vg}
N 2610 1095 2610 1170 { lab=Vg}
N 2125 1065 2125 1095 { lab=VLX}
N 2260 1065 2260 1095 { lab=VLX}
N 2410 1065 2410 1095 { lab=VLX}
N 2570 1065 2570 1095 { lab=VLX}
N 2730 1065 2730 1095 { lab=VLX}
N 2865 1065 3000 1065 { lab=VLX}
N 3000 1065 3150 1065 { lab=VLX}
N 3150 1065 3310 1065 { lab=VLX}
N 3310 1065 3470 1065 { lab=VLX}
N 2865 1125 3000 1125 { lab=Vout}
N 3000 1125 3150 1125 { lab=Vout}
N 3150 1125 3310 1125 { lab=Vout}
N 3310 1125 3470 1125 { lab=Vout}
N 2905 1095 2905 1170 { lab=Vg}
N 2905 1170 3040 1170 { lab=Vg}
N 3040 1095 3040 1170 { lab=Vg}
N 3040 1170 3195 1170 { lab=Vg}
N 3510 1095 3510 1170 { lab=Vg}
N 3195 1170 3510 1170 { lab=Vg}
N 3190 1095 3190 1170 { lab=Vg}
N 3350 1095 3350 1170 { lab=Vg}
N 2865 1065 2865 1095 { lab=VLX}
N 3000 1065 3000 1095 { lab=VLX}
N 3150 1065 3150 1095 { lab=VLX}
N 3310 1065 3310 1095 { lab=VLX}
N 3470 1065 3470 1095 { lab=VLX}
N 2730 1065 2865 1065 { lab=VLX}
N 2730 1125 2865 1125 { lab=Vout}
N 2770 1170 2905 1170 { lab=Vg}
N 1975 1065 2125 1065 { lab=VLX}
N 2015 1170 2165 1170 { lab=Vg}
N 1975 1125 2125 1125 { lab=Vout}
N 630 1230 765 1230 { lab=VLX}
N 765 1230 915 1230 { lab=VLX}
N 915 1230 1075 1230 { lab=VLX}
N 1075 1230 1235 1230 { lab=VLX}
N 630 1290 765 1290 { lab=Vout}
N 765 1290 915 1290 { lab=Vout}
N 915 1290 1075 1290 { lab=Vout}
N 1075 1290 1235 1290 { lab=Vout}
N 670 1260 670 1335 { lab=Vg}
N 670 1335 805 1335 { lab=Vg}
N 805 1260 805 1335 { lab=Vg}
N 805 1335 960 1335 { lab=Vg}
N 1275 1260 1275 1335 { lab=Vg}
N 960 1335 1275 1335 { lab=Vg}
N 955 1260 955 1335 { lab=Vg}
N 1115 1260 1115 1335 { lab=Vg}
N 630 1230 630 1260 { lab=VLX}
N 765 1230 765 1260 { lab=VLX}
N 915 1230 915 1260 { lab=VLX}
N 1075 1230 1075 1260 { lab=VLX}
N 1235 1230 1235 1260 { lab=VLX}
N 1370 1230 1505 1230 { lab=VLX}
N 1505 1230 1655 1230 { lab=VLX}
N 1655 1230 1815 1230 { lab=VLX}
N 1815 1230 1975 1230 { lab=VLX}
N 1370 1290 1505 1290 { lab=Vout}
N 1505 1290 1655 1290 { lab=Vout}
N 1655 1290 1815 1290 { lab=Vout}
N 1815 1290 1975 1290 { lab=Vout}
N 1410 1260 1410 1335 { lab=Vg}
N 1410 1335 1545 1335 { lab=Vg}
N 1545 1260 1545 1335 { lab=Vg}
N 1545 1335 1700 1335 { lab=Vg}
N 2015 1260 2015 1335 { lab=Vg}
N 1700 1335 2015 1335 { lab=Vg}
N 1695 1260 1695 1335 { lab=Vg}
N 1855 1260 1855 1335 { lab=Vg}
N 1370 1230 1370 1260 { lab=VLX}
N 1505 1230 1505 1260 { lab=VLX}
N 1655 1230 1655 1260 { lab=VLX}
N 1815 1230 1815 1260 { lab=VLX}
N 1975 1230 1975 1260 { lab=VLX}
N 1235 1230 1370 1230 { lab=VLX}
N 1235 1290 1370 1290 { lab=Vout}
N 1275 1335 1410 1335 { lab=Vg}
N 2125 1230 2260 1230 { lab=VLX}
N 2260 1230 2410 1230 { lab=VLX}
N 2410 1230 2570 1230 { lab=VLX}
N 2570 1230 2730 1230 { lab=VLX}
N 2125 1290 2260 1290 { lab=Vout}
N 2260 1290 2410 1290 { lab=Vout}
N 2410 1290 2570 1290 { lab=Vout}
N 2570 1290 2730 1290 { lab=Vout}
N 2165 1260 2165 1335 { lab=Vg}
N 2165 1335 2300 1335 { lab=Vg}
N 2300 1260 2300 1335 { lab=Vg}
N 2300 1335 2455 1335 { lab=Vg}
N 2770 1260 2770 1335 { lab=Vg}
N 2455 1335 2770 1335 { lab=Vg}
N 2450 1260 2450 1335 { lab=Vg}
N 2610 1260 2610 1335 { lab=Vg}
N 2125 1230 2125 1260 { lab=VLX}
N 2260 1230 2260 1260 { lab=VLX}
N 2410 1230 2410 1260 { lab=VLX}
N 2570 1230 2570 1260 { lab=VLX}
N 2730 1230 2730 1260 { lab=VLX}
N 2865 1230 3000 1230 { lab=VLX}
N 3000 1230 3150 1230 { lab=VLX}
N 3150 1230 3310 1230 { lab=VLX}
N 3310 1230 3470 1230 { lab=VLX}
N 2865 1290 3000 1290 { lab=Vout}
N 3000 1290 3150 1290 { lab=Vout}
N 3150 1290 3310 1290 { lab=Vout}
N 3310 1290 3470 1290 { lab=Vout}
N 2905 1260 2905 1335 { lab=Vg}
N 2905 1335 3040 1335 { lab=Vg}
N 3040 1260 3040 1335 { lab=Vg}
N 3040 1335 3195 1335 { lab=Vg}
N 3510 1260 3510 1335 { lab=Vg}
N 3195 1335 3510 1335 { lab=Vg}
N 3190 1260 3190 1335 { lab=Vg}
N 3350 1260 3350 1335 { lab=Vg}
N 2865 1230 2865 1260 { lab=VLX}
N 3000 1230 3000 1260 { lab=VLX}
N 3150 1230 3150 1260 { lab=VLX}
N 3310 1230 3310 1260 { lab=VLX}
N 3470 1230 3470 1260 { lab=VLX}
N 2730 1230 2865 1230 { lab=VLX}
N 2730 1290 2865 1290 { lab=Vout}
N 2770 1335 2905 1335 { lab=Vg}
N 1975 1230 2125 1230 { lab=VLX}
N 2015 1335 2165 1335 { lab=Vg}
N 1975 1290 2125 1290 { lab=Vout}
N 3510 1170 3510 1260 { lab=Vg}
N 385 1065 630 1065 { lab=VLX}
N 380 1230 630 1230 { lab=VLX}
N 380 1065 380 1230 { lab=VLX}
N 380 1065 385 1065 { lab=VLX}
N 500 1125 630 1125 { lab=Vout}
N 500 1125 500 1335 { lab=Vout}
N 630 1415 765 1415 { lab=VLX}
N 765 1415 915 1415 { lab=VLX}
N 915 1415 1075 1415 { lab=VLX}
N 1075 1415 1235 1415 { lab=VLX}
N 630 1475 765 1475 { lab=Vout}
N 765 1475 915 1475 { lab=Vout}
N 915 1475 1075 1475 { lab=Vout}
N 1075 1475 1235 1475 { lab=Vout}
N 670 1445 670 1520 { lab=Vg}
N 670 1520 805 1520 { lab=Vg}
N 805 1445 805 1520 { lab=Vg}
N 805 1520 960 1520 { lab=Vg}
N 1275 1445 1275 1520 { lab=Vg}
N 960 1520 1275 1520 { lab=Vg}
N 955 1445 955 1520 { lab=Vg}
N 1115 1445 1115 1520 { lab=Vg}
N 630 1415 630 1445 { lab=VLX}
N 765 1415 765 1445 { lab=VLX}
N 915 1415 915 1445 { lab=VLX}
N 1075 1415 1075 1445 { lab=VLX}
N 1235 1415 1235 1445 { lab=VLX}
N 1370 1415 1505 1415 { lab=VLX}
N 1505 1415 1655 1415 { lab=VLX}
N 1655 1415 1815 1415 { lab=VLX}
N 1815 1415 1975 1415 { lab=VLX}
N 1370 1475 1505 1475 { lab=Vout}
N 1505 1475 1655 1475 { lab=Vout}
N 1655 1475 1815 1475 { lab=Vout}
N 1815 1475 1975 1475 { lab=Vout}
N 1410 1445 1410 1520 { lab=Vg}
N 1410 1520 1545 1520 { lab=Vg}
N 1545 1445 1545 1520 { lab=Vg}
N 1545 1520 1700 1520 { lab=Vg}
N 2015 1445 2015 1520 { lab=Vg}
N 1700 1520 2015 1520 { lab=Vg}
N 1695 1445 1695 1520 { lab=Vg}
N 1855 1445 1855 1520 { lab=Vg}
N 1370 1415 1370 1445 { lab=VLX}
N 1505 1415 1505 1445 { lab=VLX}
N 1655 1415 1655 1445 { lab=VLX}
N 1815 1415 1815 1445 { lab=VLX}
N 1975 1415 1975 1445 { lab=VLX}
N 1235 1415 1370 1415 { lab=VLX}
N 1235 1475 1370 1475 { lab=Vout}
N 1275 1520 1410 1520 { lab=Vg}
N 2125 1415 2260 1415 { lab=VLX}
N 2260 1415 2410 1415 { lab=VLX}
N 2410 1415 2570 1415 { lab=VLX}
N 2570 1415 2730 1415 { lab=VLX}
N 2125 1475 2260 1475 { lab=Vout}
N 2260 1475 2410 1475 { lab=Vout}
N 2410 1475 2570 1475 { lab=Vout}
N 2570 1475 2730 1475 { lab=Vout}
N 2165 1445 2165 1520 { lab=Vg}
N 2165 1520 2300 1520 { lab=Vg}
N 2300 1445 2300 1520 { lab=Vg}
N 2300 1520 2455 1520 { lab=Vg}
N 2770 1445 2770 1520 { lab=Vg}
N 2455 1520 2770 1520 { lab=Vg}
N 2450 1445 2450 1520 { lab=Vg}
N 2610 1445 2610 1520 { lab=Vg}
N 2125 1415 2125 1445 { lab=VLX}
N 2260 1415 2260 1445 { lab=VLX}
N 2410 1415 2410 1445 { lab=VLX}
N 2570 1415 2570 1445 { lab=VLX}
N 2730 1415 2730 1445 { lab=VLX}
N 2865 1415 3000 1415 { lab=VLX}
N 3000 1415 3150 1415 { lab=VLX}
N 3150 1415 3310 1415 { lab=VLX}
N 3310 1415 3470 1415 { lab=VLX}
N 2865 1475 3000 1475 { lab=Vout}
N 3000 1475 3150 1475 { lab=Vout}
N 3150 1475 3310 1475 { lab=Vout}
N 3310 1475 3470 1475 { lab=Vout}
N 2905 1445 2905 1520 { lab=Vg}
N 2905 1520 3040 1520 { lab=Vg}
N 3040 1445 3040 1520 { lab=Vg}
N 3040 1520 3195 1520 { lab=Vg}
N 3510 1445 3510 1520 { lab=Vg}
N 3195 1520 3510 1520 { lab=Vg}
N 3190 1445 3190 1520 { lab=Vg}
N 3350 1445 3350 1520 { lab=Vg}
N 2865 1415 2865 1445 { lab=VLX}
N 3000 1415 3000 1445 { lab=VLX}
N 3150 1415 3150 1445 { lab=VLX}
N 3310 1415 3310 1445 { lab=VLX}
N 3470 1415 3470 1445 { lab=VLX}
N 2730 1415 2865 1415 { lab=VLX}
N 2730 1475 2865 1475 { lab=Vout}
N 2770 1520 2905 1520 { lab=Vg}
N 1975 1415 2125 1415 { lab=VLX}
N 2015 1520 2165 1520 { lab=Vg}
N 1975 1475 2125 1475 { lab=Vout}
N 630 1580 765 1580 { lab=VLX}
N 765 1580 915 1580 { lab=VLX}
N 915 1580 1075 1580 { lab=VLX}
N 1075 1580 1235 1580 { lab=VLX}
N 630 1640 765 1640 { lab=Vout}
N 765 1640 915 1640 { lab=Vout}
N 915 1640 1075 1640 { lab=Vout}
N 1075 1640 1235 1640 { lab=Vout}
N 670 1610 670 1685 { lab=Vg}
N 670 1685 805 1685 { lab=Vg}
N 805 1610 805 1685 { lab=Vg}
N 805 1685 960 1685 { lab=Vg}
N 1275 1610 1275 1685 { lab=Vg}
N 960 1685 1275 1685 { lab=Vg}
N 955 1610 955 1685 { lab=Vg}
N 1115 1610 1115 1685 { lab=Vg}
N 630 1580 630 1610 { lab=VLX}
N 765 1580 765 1610 { lab=VLX}
N 915 1580 915 1610 { lab=VLX}
N 1075 1580 1075 1610 { lab=VLX}
N 1235 1580 1235 1610 { lab=VLX}
N 1370 1580 1505 1580 { lab=VLX}
N 1505 1580 1655 1580 { lab=VLX}
N 1655 1580 1815 1580 { lab=VLX}
N 1815 1580 1975 1580 { lab=VLX}
N 1370 1640 1505 1640 { lab=Vout}
N 1505 1640 1655 1640 { lab=Vout}
N 1655 1640 1815 1640 { lab=Vout}
N 1815 1640 1975 1640 { lab=Vout}
N 1410 1610 1410 1685 { lab=Vg}
N 1410 1685 1545 1685 { lab=Vg}
N 1545 1610 1545 1685 { lab=Vg}
N 1545 1685 1700 1685 { lab=Vg}
N 2015 1610 2015 1685 { lab=Vg}
N 1700 1685 2015 1685 { lab=Vg}
N 1695 1610 1695 1685 { lab=Vg}
N 1855 1610 1855 1685 { lab=Vg}
N 1370 1580 1370 1610 { lab=VLX}
N 1505 1580 1505 1610 { lab=VLX}
N 1655 1580 1655 1610 { lab=VLX}
N 1815 1580 1815 1610 { lab=VLX}
N 1975 1580 1975 1610 { lab=VLX}
N 1235 1580 1370 1580 { lab=VLX}
N 1235 1640 1370 1640 { lab=Vout}
N 1275 1685 1410 1685 { lab=Vg}
N 2125 1580 2260 1580 { lab=VLX}
N 2260 1580 2410 1580 { lab=VLX}
N 2410 1580 2570 1580 { lab=VLX}
N 2570 1580 2730 1580 { lab=VLX}
N 2125 1640 2260 1640 { lab=Vout}
N 2260 1640 2410 1640 { lab=Vout}
N 2410 1640 2570 1640 { lab=Vout}
N 2570 1640 2730 1640 { lab=Vout}
N 2165 1610 2165 1685 { lab=Vg}
N 2165 1685 2300 1685 { lab=Vg}
N 2300 1610 2300 1685 { lab=Vg}
N 2300 1685 2455 1685 { lab=Vg}
N 2770 1610 2770 1685 { lab=Vg}
N 2455 1685 2770 1685 { lab=Vg}
N 2450 1610 2450 1685 { lab=Vg}
N 2610 1610 2610 1685 { lab=Vg}
N 2125 1580 2125 1610 { lab=VLX}
N 2260 1580 2260 1610 { lab=VLX}
N 2410 1580 2410 1610 { lab=VLX}
N 2570 1580 2570 1610 { lab=VLX}
N 2730 1580 2730 1610 { lab=VLX}
N 2865 1580 3000 1580 { lab=VLX}
N 3000 1580 3150 1580 { lab=VLX}
N 3150 1580 3310 1580 { lab=VLX}
N 3310 1580 3470 1580 { lab=VLX}
N 2865 1640 3000 1640 { lab=Vout}
N 3000 1640 3150 1640 { lab=Vout}
N 3150 1640 3310 1640 { lab=Vout}
N 3310 1640 3470 1640 { lab=Vout}
N 2905 1610 2905 1685 { lab=Vg}
N 2905 1685 3040 1685 { lab=Vg}
N 3040 1610 3040 1685 { lab=Vg}
N 3040 1685 3195 1685 { lab=Vg}
N 3510 1610 3510 1685 { lab=Vg}
N 3195 1685 3510 1685 { lab=Vg}
N 3190 1610 3190 1685 { lab=Vg}
N 3350 1610 3350 1685 { lab=Vg}
N 2865 1580 2865 1610 { lab=VLX}
N 3000 1580 3000 1610 { lab=VLX}
N 3150 1580 3150 1610 { lab=VLX}
N 3310 1580 3310 1610 { lab=VLX}
N 3470 1580 3470 1610 { lab=VLX}
N 2730 1580 2865 1580 { lab=VLX}
N 2730 1640 2865 1640 { lab=Vout}
N 2770 1685 2905 1685 { lab=Vg}
N 1975 1580 2125 1580 { lab=VLX}
N 2015 1685 2165 1685 { lab=Vg}
N 1975 1640 2125 1640 { lab=Vout}
N 3510 1520 3510 1610 { lab=Vg}
N 385 1415 630 1415 { lab=VLX}
N 380 1580 630 1580 { lab=VLX}
N 380 1415 380 1580 { lab=VLX}
N 380 1415 385 1415 { lab=VLX}
N 500 1475 500 1685 { lab=Vout}
N 380 1230 380 1420 { lab=VLX}
N 500 1330 500 1480 { lab=Vout}
N 3510 1330 3510 1450 { lab=Vg}
N 380 910 380 1070 { lab=VLX}
N 500 1010 500 1130 { lab=Vout}
N 3510 1020 3510 1090 { lab=Vg}
N 3510 1010 3510 1020 { lab=Vg}
N 630 1815 765 1815 { lab=VLX}
N 765 1815 915 1815 { lab=VLX}
N 915 1815 1075 1815 { lab=VLX}
N 1075 1815 1235 1815 { lab=VLX}
N 630 1875 765 1875 { lab=Vout}
N 765 1875 915 1875 { lab=Vout}
N 915 1875 1075 1875 { lab=Vout}
N 1075 1875 1235 1875 { lab=Vout}
N 670 1845 670 1920 { lab=Vg}
N 670 1920 805 1920 { lab=Vg}
N 805 1845 805 1920 { lab=Vg}
N 805 1920 960 1920 { lab=Vg}
N 1275 1845 1275 1920 { lab=Vg}
N 960 1920 1275 1920 { lab=Vg}
N 955 1845 955 1920 { lab=Vg}
N 1115 1845 1115 1920 { lab=Vg}
N 630 1815 630 1845 { lab=VLX}
N 765 1815 765 1845 { lab=VLX}
N 915 1815 915 1845 { lab=VLX}
N 1075 1815 1075 1845 { lab=VLX}
N 1235 1815 1235 1845 { lab=VLX}
N 1370 1815 1505 1815 { lab=VLX}
N 1505 1815 1655 1815 { lab=VLX}
N 1655 1815 1815 1815 { lab=VLX}
N 1815 1815 1975 1815 { lab=VLX}
N 1370 1875 1505 1875 { lab=Vout}
N 1505 1875 1655 1875 { lab=Vout}
N 1655 1875 1815 1875 { lab=Vout}
N 1815 1875 1975 1875 { lab=Vout}
N 1410 1845 1410 1920 { lab=Vg}
N 1410 1920 1545 1920 { lab=Vg}
N 1545 1845 1545 1920 { lab=Vg}
N 1545 1920 1700 1920 { lab=Vg}
N 2015 1845 2015 1920 { lab=Vg}
N 1700 1920 2015 1920 { lab=Vg}
N 1695 1845 1695 1920 { lab=Vg}
N 1855 1845 1855 1920 { lab=Vg}
N 1370 1815 1370 1845 { lab=VLX}
N 1505 1815 1505 1845 { lab=VLX}
N 1655 1815 1655 1845 { lab=VLX}
N 1815 1815 1815 1845 { lab=VLX}
N 1975 1815 1975 1845 { lab=VLX}
N 1235 1815 1370 1815 { lab=VLX}
N 1235 1875 1370 1875 { lab=Vout}
N 1275 1920 1410 1920 { lab=Vg}
N 2125 1815 2260 1815 { lab=VLX}
N 2260 1815 2410 1815 { lab=VLX}
N 2410 1815 2570 1815 { lab=VLX}
N 2570 1815 2730 1815 { lab=VLX}
N 2125 1875 2260 1875 { lab=Vout}
N 2260 1875 2410 1875 { lab=Vout}
N 2410 1875 2570 1875 { lab=Vout}
N 2570 1875 2730 1875 { lab=Vout}
N 2165 1845 2165 1920 { lab=Vg}
N 2165 1920 2300 1920 { lab=Vg}
N 2300 1845 2300 1920 { lab=Vg}
N 2300 1920 2455 1920 { lab=Vg}
N 2770 1845 2770 1920 { lab=Vg}
N 2455 1920 2770 1920 { lab=Vg}
N 2450 1845 2450 1920 { lab=Vg}
N 2610 1845 2610 1920 { lab=Vg}
N 2125 1815 2125 1845 { lab=VLX}
N 2260 1815 2260 1845 { lab=VLX}
N 2410 1815 2410 1845 { lab=VLX}
N 2570 1815 2570 1845 { lab=VLX}
N 2730 1815 2730 1845 { lab=VLX}
N 2865 1815 3000 1815 { lab=VLX}
N 3000 1815 3150 1815 { lab=VLX}
N 3150 1815 3310 1815 { lab=VLX}
N 3310 1815 3470 1815 { lab=VLX}
N 2865 1875 3000 1875 { lab=Vout}
N 3000 1875 3150 1875 { lab=Vout}
N 3150 1875 3310 1875 { lab=Vout}
N 3310 1875 3470 1875 { lab=Vout}
N 2905 1845 2905 1920 { lab=Vg}
N 2905 1920 3040 1920 { lab=Vg}
N 3040 1845 3040 1920 { lab=Vg}
N 3040 1920 3195 1920 { lab=Vg}
N 3510 1845 3510 1920 { lab=Vg}
N 3195 1920 3510 1920 { lab=Vg}
N 3190 1845 3190 1920 { lab=Vg}
N 3350 1845 3350 1920 { lab=Vg}
N 2865 1815 2865 1845 { lab=VLX}
N 3000 1815 3000 1845 { lab=VLX}
N 3150 1815 3150 1845 { lab=VLX}
N 3310 1815 3310 1845 { lab=VLX}
N 3470 1815 3470 1845 { lab=VLX}
N 2730 1815 2865 1815 { lab=VLX}
N 2730 1875 2865 1875 { lab=Vout}
N 2770 1920 2905 1920 { lab=Vg}
N 1975 1815 2125 1815 { lab=VLX}
N 2015 1920 2165 1920 { lab=Vg}
N 1975 1875 2125 1875 { lab=Vout}
N 630 1980 765 1980 { lab=VLX}
N 765 1980 915 1980 { lab=VLX}
N 915 1980 1075 1980 { lab=VLX}
N 1075 1980 1235 1980 { lab=VLX}
N 630 2040 765 2040 { lab=Vout}
N 765 2040 915 2040 { lab=Vout}
N 915 2040 1075 2040 { lab=Vout}
N 1075 2040 1235 2040 { lab=Vout}
N 670 2010 670 2085 { lab=Vg}
N 670 2085 805 2085 { lab=Vg}
N 805 2010 805 2085 { lab=Vg}
N 805 2085 960 2085 { lab=Vg}
N 1275 2010 1275 2085 { lab=Vg}
N 960 2085 1275 2085 { lab=Vg}
N 955 2010 955 2085 { lab=Vg}
N 1115 2010 1115 2085 { lab=Vg}
N 630 1980 630 2010 { lab=VLX}
N 765 1980 765 2010 { lab=VLX}
N 915 1980 915 2010 { lab=VLX}
N 1075 1980 1075 2010 { lab=VLX}
N 1235 1980 1235 2010 { lab=VLX}
N 1370 1980 1505 1980 { lab=VLX}
N 1505 1980 1655 1980 { lab=VLX}
N 1655 1980 1815 1980 { lab=VLX}
N 1815 1980 1975 1980 { lab=VLX}
N 1370 2040 1505 2040 { lab=Vout}
N 1505 2040 1655 2040 { lab=Vout}
N 1655 2040 1815 2040 { lab=Vout}
N 1815 2040 1975 2040 { lab=Vout}
N 1410 2010 1410 2085 { lab=Vg}
N 1410 2085 1545 2085 { lab=Vg}
N 1545 2010 1545 2085 { lab=Vg}
N 1545 2085 1700 2085 { lab=Vg}
N 2015 2010 2015 2085 { lab=Vg}
N 1700 2085 2015 2085 { lab=Vg}
N 1695 2010 1695 2085 { lab=Vg}
N 1855 2010 1855 2085 { lab=Vg}
N 1370 1980 1370 2010 { lab=VLX}
N 1505 1980 1505 2010 { lab=VLX}
N 1655 1980 1655 2010 { lab=VLX}
N 1815 1980 1815 2010 { lab=VLX}
N 1975 1980 1975 2010 { lab=VLX}
N 1235 1980 1370 1980 { lab=VLX}
N 1235 2040 1370 2040 { lab=Vout}
N 1275 2085 1410 2085 { lab=Vg}
N 2125 1980 2260 1980 { lab=VLX}
N 2260 1980 2410 1980 { lab=VLX}
N 2410 1980 2570 1980 { lab=VLX}
N 2570 1980 2730 1980 { lab=VLX}
N 2125 2040 2260 2040 { lab=Vout}
N 2260 2040 2410 2040 { lab=Vout}
N 2410 2040 2570 2040 { lab=Vout}
N 2570 2040 2730 2040 { lab=Vout}
N 2165 2010 2165 2085 { lab=Vg}
N 2165 2085 2300 2085 { lab=Vg}
N 2300 2010 2300 2085 { lab=Vg}
N 2300 2085 2455 2085 { lab=Vg}
N 2770 2010 2770 2085 { lab=Vg}
N 2455 2085 2770 2085 { lab=Vg}
N 2450 2010 2450 2085 { lab=Vg}
N 2610 2010 2610 2085 { lab=Vg}
N 2125 1980 2125 2010 { lab=VLX}
N 2260 1980 2260 2010 { lab=VLX}
N 2410 1980 2410 2010 { lab=VLX}
N 2570 1980 2570 2010 { lab=VLX}
N 2730 1980 2730 2010 { lab=VLX}
N 2865 1980 3000 1980 { lab=VLX}
N 3000 1980 3150 1980 { lab=VLX}
N 3150 1980 3310 1980 { lab=VLX}
N 3310 1980 3470 1980 { lab=VLX}
N 2865 2040 3000 2040 { lab=Vout}
N 3000 2040 3150 2040 { lab=Vout}
N 3150 2040 3310 2040 { lab=Vout}
N 3310 2040 3470 2040 { lab=Vout}
N 2905 2010 2905 2085 { lab=Vg}
N 2905 2085 3040 2085 { lab=Vg}
N 3040 2010 3040 2085 { lab=Vg}
N 3040 2085 3195 2085 { lab=Vg}
N 3510 2010 3510 2085 { lab=Vg}
N 3195 2085 3510 2085 { lab=Vg}
N 3190 2010 3190 2085 { lab=Vg}
N 3350 2010 3350 2085 { lab=Vg}
N 2865 1980 2865 2010 { lab=VLX}
N 3000 1980 3000 2010 { lab=VLX}
N 3150 1980 3150 2010 { lab=VLX}
N 3310 1980 3310 2010 { lab=VLX}
N 3470 1980 3470 2010 { lab=VLX}
N 2730 1980 2865 1980 { lab=VLX}
N 2730 2040 2865 2040 { lab=Vout}
N 2770 2085 2905 2085 { lab=Vg}
N 1975 1980 2125 1980 { lab=VLX}
N 2015 2085 2165 2085 { lab=Vg}
N 1975 2040 2125 2040 { lab=Vout}
N 3510 1920 3510 2010 { lab=Vg}
N 385 1815 630 1815 { lab=VLX}
N 380 1980 630 1980 { lab=VLX}
N 380 1815 380 1980 { lab=VLX}
N 380 1815 385 1815 { lab=VLX}
N 500 1875 630 1875 { lab=Vout}
N 500 1875 500 2085 { lab=Vout}
N 630 2165 765 2165 { lab=VLX}
N 765 2165 915 2165 { lab=VLX}
N 915 2165 1075 2165 { lab=VLX}
N 1075 2165 1235 2165 { lab=VLX}
N 630 2225 765 2225 { lab=Vout}
N 765 2225 915 2225 { lab=Vout}
N 915 2225 1075 2225 { lab=Vout}
N 1075 2225 1235 2225 { lab=Vout}
N 670 2195 670 2270 { lab=Vg}
N 670 2270 805 2270 { lab=Vg}
N 805 2195 805 2270 { lab=Vg}
N 805 2270 960 2270 { lab=Vg}
N 1275 2195 1275 2270 { lab=Vg}
N 960 2270 1275 2270 { lab=Vg}
N 955 2195 955 2270 { lab=Vg}
N 1115 2195 1115 2270 { lab=Vg}
N 630 2165 630 2195 { lab=VLX}
N 765 2165 765 2195 { lab=VLX}
N 915 2165 915 2195 { lab=VLX}
N 1075 2165 1075 2195 { lab=VLX}
N 1235 2165 1235 2195 { lab=VLX}
N 1370 2165 1505 2165 { lab=VLX}
N 1505 2165 1655 2165 { lab=VLX}
N 1655 2165 1815 2165 { lab=VLX}
N 1815 2165 1975 2165 { lab=VLX}
N 1370 2225 1505 2225 { lab=Vout}
N 1505 2225 1655 2225 { lab=Vout}
N 1655 2225 1815 2225 { lab=Vout}
N 1815 2225 1975 2225 { lab=Vout}
N 1410 2195 1410 2270 { lab=Vg}
N 1410 2270 1545 2270 { lab=Vg}
N 1545 2195 1545 2270 { lab=Vg}
N 1545 2270 1700 2270 { lab=Vg}
N 2015 2195 2015 2270 { lab=Vg}
N 1700 2270 2015 2270 { lab=Vg}
N 1695 2195 1695 2270 { lab=Vg}
N 1855 2195 1855 2270 { lab=Vg}
N 1370 2165 1370 2195 { lab=VLX}
N 1505 2165 1505 2195 { lab=VLX}
N 1655 2165 1655 2195 { lab=VLX}
N 1815 2165 1815 2195 { lab=VLX}
N 1975 2165 1975 2195 { lab=VLX}
N 1235 2165 1370 2165 { lab=VLX}
N 1235 2225 1370 2225 { lab=Vout}
N 1275 2270 1410 2270 { lab=Vg}
N 2125 2165 2260 2165 { lab=VLX}
N 2260 2165 2410 2165 { lab=VLX}
N 2410 2165 2570 2165 { lab=VLX}
N 2570 2165 2730 2165 { lab=VLX}
N 2125 2225 2260 2225 { lab=Vout}
N 2260 2225 2410 2225 { lab=Vout}
N 2410 2225 2570 2225 { lab=Vout}
N 2570 2225 2730 2225 { lab=Vout}
N 2165 2195 2165 2270 { lab=Vg}
N 2165 2270 2300 2270 { lab=Vg}
N 2300 2195 2300 2270 { lab=Vg}
N 2300 2270 2455 2270 { lab=Vg}
N 2770 2195 2770 2270 { lab=Vg}
N 2455 2270 2770 2270 { lab=Vg}
N 2450 2195 2450 2270 { lab=Vg}
N 2610 2195 2610 2270 { lab=Vg}
N 2125 2165 2125 2195 { lab=VLX}
N 2260 2165 2260 2195 { lab=VLX}
N 2410 2165 2410 2195 { lab=VLX}
N 2570 2165 2570 2195 { lab=VLX}
N 2730 2165 2730 2195 { lab=VLX}
N 2865 2165 3000 2165 { lab=VLX}
N 3000 2165 3150 2165 { lab=VLX}
N 3150 2165 3310 2165 { lab=VLX}
N 3310 2165 3470 2165 { lab=VLX}
N 2865 2225 3000 2225 { lab=Vout}
N 3000 2225 3150 2225 { lab=Vout}
N 3150 2225 3310 2225 { lab=Vout}
N 3310 2225 3470 2225 { lab=Vout}
N 2905 2195 2905 2270 { lab=Vg}
N 2905 2270 3040 2270 { lab=Vg}
N 3040 2195 3040 2270 { lab=Vg}
N 3040 2270 3195 2270 { lab=Vg}
N 3510 2195 3510 2270 { lab=Vg}
N 3195 2270 3510 2270 { lab=Vg}
N 3190 2195 3190 2270 { lab=Vg}
N 3350 2195 3350 2270 { lab=Vg}
N 2865 2165 2865 2195 { lab=VLX}
N 3000 2165 3000 2195 { lab=VLX}
N 3150 2165 3150 2195 { lab=VLX}
N 3310 2165 3310 2195 { lab=VLX}
N 3470 2165 3470 2195 { lab=VLX}
N 2730 2165 2865 2165 { lab=VLX}
N 2730 2225 2865 2225 { lab=Vout}
N 2770 2270 2905 2270 { lab=Vg}
N 1975 2165 2125 2165 { lab=VLX}
N 2015 2270 2165 2270 { lab=Vg}
N 1975 2225 2125 2225 { lab=Vout}
N 630 2330 765 2330 { lab=VLX}
N 765 2330 915 2330 { lab=VLX}
N 915 2330 1075 2330 { lab=VLX}
N 1075 2330 1235 2330 { lab=VLX}
N 630 2390 765 2390 { lab=Vout}
N 765 2390 915 2390 { lab=Vout}
N 915 2390 1075 2390 { lab=Vout}
N 1075 2390 1235 2390 { lab=Vout}
N 670 2360 670 2435 { lab=Vg}
N 670 2435 805 2435 { lab=Vg}
N 805 2360 805 2435 { lab=Vg}
N 805 2435 960 2435 { lab=Vg}
N 1275 2360 1275 2435 { lab=Vg}
N 960 2435 1275 2435 { lab=Vg}
N 955 2360 955 2435 { lab=Vg}
N 1115 2360 1115 2435 { lab=Vg}
N 630 2330 630 2360 { lab=VLX}
N 765 2330 765 2360 { lab=VLX}
N 915 2330 915 2360 { lab=VLX}
N 1075 2330 1075 2360 { lab=VLX}
N 1235 2330 1235 2360 { lab=VLX}
N 1370 2330 1505 2330 { lab=VLX}
N 1505 2330 1655 2330 { lab=VLX}
N 1655 2330 1815 2330 { lab=VLX}
N 1815 2330 1975 2330 { lab=VLX}
N 1370 2390 1505 2390 { lab=Vout}
N 1505 2390 1655 2390 { lab=Vout}
N 1655 2390 1815 2390 { lab=Vout}
N 1815 2390 1975 2390 { lab=Vout}
N 1410 2360 1410 2435 { lab=Vg}
N 1410 2435 1545 2435 { lab=Vg}
N 1545 2360 1545 2435 { lab=Vg}
N 1545 2435 1700 2435 { lab=Vg}
N 2015 2360 2015 2435 { lab=Vg}
N 1700 2435 2015 2435 { lab=Vg}
N 1695 2360 1695 2435 { lab=Vg}
N 1855 2360 1855 2435 { lab=Vg}
N 1370 2330 1370 2360 { lab=VLX}
N 1505 2330 1505 2360 { lab=VLX}
N 1655 2330 1655 2360 { lab=VLX}
N 1815 2330 1815 2360 { lab=VLX}
N 1975 2330 1975 2360 { lab=VLX}
N 1235 2330 1370 2330 { lab=VLX}
N 1235 2390 1370 2390 { lab=Vout}
N 1275 2435 1410 2435 { lab=Vg}
N 2125 2330 2260 2330 { lab=VLX}
N 2260 2330 2410 2330 { lab=VLX}
N 2410 2330 2570 2330 { lab=VLX}
N 2570 2330 2730 2330 { lab=VLX}
N 2125 2390 2260 2390 { lab=Vout}
N 2260 2390 2410 2390 { lab=Vout}
N 2410 2390 2570 2390 { lab=Vout}
N 2570 2390 2730 2390 { lab=Vout}
N 2165 2360 2165 2435 { lab=Vg}
N 2165 2435 2300 2435 { lab=Vg}
N 2300 2360 2300 2435 { lab=Vg}
N 2300 2435 2455 2435 { lab=Vg}
N 2770 2360 2770 2435 { lab=Vg}
N 2455 2435 2770 2435 { lab=Vg}
N 2450 2360 2450 2435 { lab=Vg}
N 2610 2360 2610 2435 { lab=Vg}
N 2125 2330 2125 2360 { lab=VLX}
N 2260 2330 2260 2360 { lab=VLX}
N 2410 2330 2410 2360 { lab=VLX}
N 2570 2330 2570 2360 { lab=VLX}
N 2730 2330 2730 2360 { lab=VLX}
N 2865 2330 3000 2330 { lab=VLX}
N 3000 2330 3150 2330 { lab=VLX}
N 3150 2330 3310 2330 { lab=VLX}
N 3310 2330 3470 2330 { lab=VLX}
N 2865 2390 3000 2390 { lab=Vout}
N 3000 2390 3150 2390 { lab=Vout}
N 3150 2390 3310 2390 { lab=Vout}
N 3310 2390 3470 2390 { lab=Vout}
N 2905 2360 2905 2435 { lab=Vg}
N 2905 2435 3040 2435 { lab=Vg}
N 3040 2360 3040 2435 { lab=Vg}
N 3040 2435 3195 2435 { lab=Vg}
N 3510 2360 3510 2435 { lab=Vg}
N 3195 2435 3510 2435 { lab=Vg}
N 3190 2360 3190 2435 { lab=Vg}
N 3350 2360 3350 2435 { lab=Vg}
N 2865 2330 2865 2360 { lab=VLX}
N 3000 2330 3000 2360 { lab=VLX}
N 3150 2330 3150 2360 { lab=VLX}
N 3310 2330 3310 2360 { lab=VLX}
N 3470 2330 3470 2360 { lab=VLX}
N 2730 2330 2865 2330 { lab=VLX}
N 2730 2390 2865 2390 { lab=Vout}
N 2770 2435 2905 2435 { lab=Vg}
N 1975 2330 2125 2330 { lab=VLX}
N 2015 2435 2165 2435 { lab=Vg}
N 1975 2390 2125 2390 { lab=Vout}
N 3510 2270 3510 2360 { lab=Vg}
N 385 2165 630 2165 { lab=VLX}
N 380 2330 630 2330 { lab=VLX}
N 380 2165 380 2330 { lab=VLX}
N 380 2165 385 2165 { lab=VLX}
N 500 2225 630 2225 { lab=Vout}
N 500 2225 500 2435 { lab=Vout}
N 380 1980 380 2170 { lab=VLX}
N 500 2080 500 2230 { lab=Vout}
N 3510 2080 3510 2200 { lab=Vg}
N 630 2485 765 2485 { lab=VLX}
N 765 2485 915 2485 { lab=VLX}
N 915 2485 1075 2485 { lab=VLX}
N 1075 2485 1235 2485 { lab=VLX}
N 630 2545 765 2545 { lab=Vout}
N 765 2545 915 2545 { lab=Vout}
N 915 2545 1075 2545 { lab=Vout}
N 1075 2545 1235 2545 { lab=Vout}
N 670 2515 670 2590 { lab=Vg}
N 670 2590 805 2590 { lab=Vg}
N 805 2515 805 2590 { lab=Vg}
N 805 2590 960 2590 { lab=Vg}
N 1275 2515 1275 2590 { lab=Vg}
N 960 2590 1275 2590 { lab=Vg}
N 955 2515 955 2590 { lab=Vg}
N 1115 2515 1115 2590 { lab=Vg}
N 630 2485 630 2515 { lab=VLX}
N 765 2485 765 2515 { lab=VLX}
N 915 2485 915 2515 { lab=VLX}
N 1075 2485 1075 2515 { lab=VLX}
N 1235 2485 1235 2515 { lab=VLX}
N 1370 2485 1505 2485 { lab=VLX}
N 1505 2485 1655 2485 { lab=VLX}
N 1655 2485 1815 2485 { lab=VLX}
N 1815 2485 1975 2485 { lab=VLX}
N 1370 2545 1505 2545 { lab=Vout}
N 1505 2545 1655 2545 { lab=Vout}
N 1655 2545 1815 2545 { lab=Vout}
N 1815 2545 1975 2545 { lab=Vout}
N 1410 2515 1410 2590 { lab=Vg}
N 1410 2590 1545 2590 { lab=Vg}
N 1545 2515 1545 2590 { lab=Vg}
N 1545 2590 1700 2590 { lab=Vg}
N 2015 2515 2015 2590 { lab=Vg}
N 1700 2590 2015 2590 { lab=Vg}
N 1695 2515 1695 2590 { lab=Vg}
N 1855 2515 1855 2590 { lab=Vg}
N 1370 2485 1370 2515 { lab=VLX}
N 1505 2485 1505 2515 { lab=VLX}
N 1655 2485 1655 2515 { lab=VLX}
N 1815 2485 1815 2515 { lab=VLX}
N 1975 2485 1975 2515 { lab=VLX}
N 1235 2485 1370 2485 { lab=VLX}
N 1235 2545 1370 2545 { lab=Vout}
N 1275 2590 1410 2590 { lab=Vg}
N 2125 2485 2260 2485 { lab=VLX}
N 2260 2485 2410 2485 { lab=VLX}
N 2410 2485 2570 2485 { lab=VLX}
N 2570 2485 2730 2485 { lab=VLX}
N 2125 2545 2260 2545 { lab=Vout}
N 2260 2545 2410 2545 { lab=Vout}
N 2410 2545 2570 2545 { lab=Vout}
N 2570 2545 2730 2545 { lab=Vout}
N 2165 2515 2165 2590 { lab=Vg}
N 2165 2590 2300 2590 { lab=Vg}
N 2300 2515 2300 2590 { lab=Vg}
N 2300 2590 2455 2590 { lab=Vg}
N 2770 2515 2770 2590 { lab=Vg}
N 2455 2590 2770 2590 { lab=Vg}
N 2450 2515 2450 2590 { lab=Vg}
N 2610 2515 2610 2590 { lab=Vg}
N 2125 2485 2125 2515 { lab=VLX}
N 2260 2485 2260 2515 { lab=VLX}
N 2410 2485 2410 2515 { lab=VLX}
N 2570 2485 2570 2515 { lab=VLX}
N 2730 2485 2730 2515 { lab=VLX}
N 2865 2485 3000 2485 { lab=VLX}
N 3000 2485 3150 2485 { lab=VLX}
N 3150 2485 3310 2485 { lab=VLX}
N 3310 2485 3470 2485 { lab=VLX}
N 2865 2545 3000 2545 { lab=Vout}
N 3000 2545 3150 2545 { lab=Vout}
N 3150 2545 3310 2545 { lab=Vout}
N 3310 2545 3470 2545 { lab=Vout}
N 2905 2515 2905 2590 { lab=Vg}
N 2905 2590 3040 2590 { lab=Vg}
N 3040 2515 3040 2590 { lab=Vg}
N 3040 2590 3195 2590 { lab=Vg}
N 3510 2515 3510 2590 { lab=Vg}
N 3195 2590 3510 2590 { lab=Vg}
N 3190 2515 3190 2590 { lab=Vg}
N 3350 2515 3350 2590 { lab=Vg}
N 2865 2485 2865 2515 { lab=VLX}
N 3000 2485 3000 2515 { lab=VLX}
N 3150 2485 3150 2515 { lab=VLX}
N 3310 2485 3310 2515 { lab=VLX}
N 3470 2485 3470 2515 { lab=VLX}
N 2730 2485 2865 2485 { lab=VLX}
N 2730 2545 2865 2545 { lab=Vout}
N 2770 2590 2905 2590 { lab=Vg}
N 1975 2485 2125 2485 { lab=VLX}
N 2015 2590 2165 2590 { lab=Vg}
N 1975 2545 2125 2545 { lab=Vout}
N 630 2650 765 2650 { lab=VLX}
N 765 2650 915 2650 { lab=VLX}
N 915 2650 1075 2650 { lab=VLX}
N 1075 2650 1235 2650 { lab=VLX}
N 630 2710 765 2710 { lab=Vout}
N 765 2710 915 2710 { lab=Vout}
N 915 2710 1075 2710 { lab=Vout}
N 1075 2710 1235 2710 { lab=Vout}
N 670 2680 670 2755 { lab=Vg}
N 670 2755 805 2755 { lab=Vg}
N 805 2680 805 2755 { lab=Vg}
N 805 2755 960 2755 { lab=Vg}
N 1275 2680 1275 2755 { lab=Vg}
N 960 2755 1275 2755 { lab=Vg}
N 955 2680 955 2755 { lab=Vg}
N 1115 2680 1115 2755 { lab=Vg}
N 630 2650 630 2680 { lab=VLX}
N 765 2650 765 2680 { lab=VLX}
N 915 2650 915 2680 { lab=VLX}
N 1075 2650 1075 2680 { lab=VLX}
N 1235 2650 1235 2680 { lab=VLX}
N 1370 2650 1505 2650 { lab=VLX}
N 1505 2650 1655 2650 { lab=VLX}
N 1655 2650 1815 2650 { lab=VLX}
N 1815 2650 1975 2650 { lab=VLX}
N 1370 2710 1505 2710 { lab=Vout}
N 1505 2710 1655 2710 { lab=Vout}
N 1655 2710 1815 2710 { lab=Vout}
N 1815 2710 1975 2710 { lab=Vout}
N 1410 2680 1410 2755 { lab=Vg}
N 1410 2755 1545 2755 { lab=Vg}
N 1545 2680 1545 2755 { lab=Vg}
N 1545 2755 1700 2755 { lab=Vg}
N 2015 2680 2015 2755 { lab=Vg}
N 1700 2755 2015 2755 { lab=Vg}
N 1695 2680 1695 2755 { lab=Vg}
N 1855 2680 1855 2755 { lab=Vg}
N 1370 2650 1370 2680 { lab=VLX}
N 1505 2650 1505 2680 { lab=VLX}
N 1655 2650 1655 2680 { lab=VLX}
N 1815 2650 1815 2680 { lab=VLX}
N 1975 2650 1975 2680 { lab=VLX}
N 1235 2650 1370 2650 { lab=VLX}
N 1235 2710 1370 2710 { lab=Vout}
N 1275 2755 1410 2755 { lab=Vg}
N 2125 2650 2260 2650 { lab=VLX}
N 2260 2650 2410 2650 { lab=VLX}
N 2410 2650 2570 2650 { lab=VLX}
N 2570 2650 2730 2650 { lab=VLX}
N 2125 2710 2260 2710 { lab=Vout}
N 2260 2710 2410 2710 { lab=Vout}
N 2410 2710 2570 2710 { lab=Vout}
N 2570 2710 2730 2710 { lab=Vout}
N 2165 2680 2165 2755 { lab=Vg}
N 2165 2755 2300 2755 { lab=Vg}
N 2300 2680 2300 2755 { lab=Vg}
N 2300 2755 2455 2755 { lab=Vg}
N 2770 2680 2770 2755 { lab=Vg}
N 2455 2755 2770 2755 { lab=Vg}
N 2450 2680 2450 2755 { lab=Vg}
N 2610 2680 2610 2755 { lab=Vg}
N 2125 2650 2125 2680 { lab=VLX}
N 2260 2650 2260 2680 { lab=VLX}
N 2410 2650 2410 2680 { lab=VLX}
N 2570 2650 2570 2680 { lab=VLX}
N 2730 2650 2730 2680 { lab=VLX}
N 2865 2650 3000 2650 { lab=VLX}
N 3000 2650 3150 2650 { lab=VLX}
N 3150 2650 3310 2650 { lab=VLX}
N 3310 2650 3470 2650 { lab=VLX}
N 2865 2710 3000 2710 { lab=Vout}
N 3000 2710 3150 2710 { lab=Vout}
N 3150 2710 3310 2710 { lab=Vout}
N 3310 2710 3470 2710 { lab=Vout}
N 2905 2680 2905 2755 { lab=Vg}
N 2905 2755 3040 2755 { lab=Vg}
N 3040 2680 3040 2755 { lab=Vg}
N 3040 2755 3195 2755 { lab=Vg}
N 3510 2680 3510 2755 { lab=Vg}
N 3195 2755 3510 2755 { lab=Vg}
N 3190 2680 3190 2755 { lab=Vg}
N 3350 2680 3350 2755 { lab=Vg}
N 2865 2650 2865 2680 { lab=VLX}
N 3000 2650 3000 2680 { lab=VLX}
N 3150 2650 3150 2680 { lab=VLX}
N 3310 2650 3310 2680 { lab=VLX}
N 3470 2650 3470 2680 { lab=VLX}
N 2730 2650 2865 2650 { lab=VLX}
N 2730 2710 2865 2710 { lab=Vout}
N 2770 2755 2905 2755 { lab=Vg}
N 1975 2650 2125 2650 { lab=VLX}
N 2015 2755 2165 2755 { lab=Vg}
N 1975 2710 2125 2710 { lab=Vout}
N 3510 2590 3510 2680 { lab=Vg}
N 385 2485 630 2485 { lab=VLX}
N 380 2650 630 2650 { lab=VLX}
N 380 2485 380 2650 { lab=VLX}
N 380 2485 385 2485 { lab=VLX}
N 500 2545 500 2755 { lab=Vout}
N 630 2835 765 2835 { lab=VLX}
N 765 2835 915 2835 { lab=VLX}
N 915 2835 1075 2835 { lab=VLX}
N 1075 2835 1235 2835 { lab=VLX}
N 630 2895 765 2895 { lab=Vout}
N 765 2895 915 2895 { lab=Vout}
N 915 2895 1075 2895 { lab=Vout}
N 1075 2895 1235 2895 { lab=Vout}
N 670 2865 670 2940 { lab=Vg}
N 670 2940 805 2940 { lab=Vg}
N 805 2865 805 2940 { lab=Vg}
N 805 2940 960 2940 { lab=Vg}
N 1275 2865 1275 2940 { lab=Vg}
N 960 2940 1275 2940 { lab=Vg}
N 955 2865 955 2940 { lab=Vg}
N 1115 2865 1115 2940 { lab=Vg}
N 630 2835 630 2865 { lab=VLX}
N 765 2835 765 2865 { lab=VLX}
N 915 2835 915 2865 { lab=VLX}
N 1075 2835 1075 2865 { lab=VLX}
N 1235 2835 1235 2865 { lab=VLX}
N 1370 2835 1505 2835 { lab=VLX}
N 1505 2835 1655 2835 { lab=VLX}
N 1655 2835 1815 2835 { lab=VLX}
N 1815 2835 1975 2835 { lab=VLX}
N 1370 2895 1505 2895 { lab=Vout}
N 1505 2895 1655 2895 { lab=Vout}
N 1655 2895 1815 2895 { lab=Vout}
N 1815 2895 1975 2895 { lab=Vout}
N 1410 2865 1410 2940 { lab=Vg}
N 1410 2940 1545 2940 { lab=Vg}
N 1545 2865 1545 2940 { lab=Vg}
N 1545 2940 1700 2940 { lab=Vg}
N 2015 2865 2015 2940 { lab=Vg}
N 1700 2940 2015 2940 { lab=Vg}
N 1695 2865 1695 2940 { lab=Vg}
N 1855 2865 1855 2940 { lab=Vg}
N 1370 2835 1370 2865 { lab=VLX}
N 1505 2835 1505 2865 { lab=VLX}
N 1655 2835 1655 2865 { lab=VLX}
N 1815 2835 1815 2865 { lab=VLX}
N 1975 2835 1975 2865 { lab=VLX}
N 1235 2835 1370 2835 { lab=VLX}
N 1235 2895 1370 2895 { lab=Vout}
N 1275 2940 1410 2940 { lab=Vg}
N 2125 2835 2260 2835 { lab=VLX}
N 2260 2835 2410 2835 { lab=VLX}
N 2410 2835 2570 2835 { lab=VLX}
N 2570 2835 2730 2835 { lab=VLX}
N 2125 2895 2260 2895 { lab=Vout}
N 2260 2895 2410 2895 { lab=Vout}
N 2410 2895 2570 2895 { lab=Vout}
N 2570 2895 2730 2895 { lab=Vout}
N 2165 2865 2165 2940 { lab=Vg}
N 2165 2940 2300 2940 { lab=Vg}
N 2300 2865 2300 2940 { lab=Vg}
N 2300 2940 2455 2940 { lab=Vg}
N 2770 2865 2770 2940 { lab=Vg}
N 2455 2940 2770 2940 { lab=Vg}
N 2450 2865 2450 2940 { lab=Vg}
N 2610 2865 2610 2940 { lab=Vg}
N 2125 2835 2125 2865 { lab=VLX}
N 2260 2835 2260 2865 { lab=VLX}
N 2410 2835 2410 2865 { lab=VLX}
N 2570 2835 2570 2865 { lab=VLX}
N 2730 2835 2730 2865 { lab=VLX}
N 2865 2835 3000 2835 { lab=VLX}
N 3000 2835 3150 2835 { lab=VLX}
N 3150 2835 3310 2835 { lab=VLX}
N 3310 2835 3470 2835 { lab=VLX}
N 2865 2895 3000 2895 { lab=Vout}
N 3000 2895 3150 2895 { lab=Vout}
N 3150 2895 3310 2895 { lab=Vout}
N 3310 2895 3470 2895 { lab=Vout}
N 2905 2865 2905 2940 { lab=Vg}
N 2905 2940 3040 2940 { lab=Vg}
N 3040 2865 3040 2940 { lab=Vg}
N 3040 2940 3195 2940 { lab=Vg}
N 3510 2865 3510 2940 { lab=Vg}
N 3195 2940 3510 2940 { lab=Vg}
N 3190 2865 3190 2940 { lab=Vg}
N 3350 2865 3350 2940 { lab=Vg}
N 2865 2835 2865 2865 { lab=VLX}
N 3000 2835 3000 2865 { lab=VLX}
N 3150 2835 3150 2865 { lab=VLX}
N 3310 2835 3310 2865 { lab=VLX}
N 3470 2835 3470 2865 { lab=VLX}
N 2730 2835 2865 2835 { lab=VLX}
N 2730 2895 2865 2895 { lab=Vout}
N 2770 2940 2905 2940 { lab=Vg}
N 1975 2835 2125 2835 { lab=VLX}
N 2015 2940 2165 2940 { lab=Vg}
N 1975 2895 2125 2895 { lab=Vout}
N 630 3000 765 3000 { lab=VLX}
N 765 3000 915 3000 { lab=VLX}
N 915 3000 1075 3000 { lab=VLX}
N 1075 3000 1235 3000 { lab=VLX}
N 630 3060 765 3060 { lab=Vout}
N 765 3060 915 3060 { lab=Vout}
N 915 3060 1075 3060 { lab=Vout}
N 1075 3060 1235 3060 { lab=Vout}
N 670 3030 670 3105 { lab=Vg}
N 670 3105 805 3105 { lab=Vg}
N 805 3030 805 3105 { lab=Vg}
N 805 3105 960 3105 { lab=Vg}
N 1275 3030 1275 3105 { lab=Vg}
N 960 3105 1275 3105 { lab=Vg}
N 955 3030 955 3105 { lab=Vg}
N 1115 3030 1115 3105 { lab=Vg}
N 630 3000 630 3030 { lab=VLX}
N 765 3000 765 3030 { lab=VLX}
N 915 3000 915 3030 { lab=VLX}
N 1075 3000 1075 3030 { lab=VLX}
N 1235 3000 1235 3030 { lab=VLX}
N 1370 3000 1505 3000 { lab=VLX}
N 1505 3000 1655 3000 { lab=VLX}
N 1655 3000 1815 3000 { lab=VLX}
N 1815 3000 1975 3000 { lab=VLX}
N 1370 3060 1505 3060 { lab=Vout}
N 1505 3060 1655 3060 { lab=Vout}
N 1655 3060 1815 3060 { lab=Vout}
N 1815 3060 1975 3060 { lab=Vout}
N 1410 3030 1410 3105 { lab=Vg}
N 1410 3105 1545 3105 { lab=Vg}
N 1545 3030 1545 3105 { lab=Vg}
N 1545 3105 1700 3105 { lab=Vg}
N 2015 3030 2015 3105 { lab=Vg}
N 1700 3105 2015 3105 { lab=Vg}
N 1695 3030 1695 3105 { lab=Vg}
N 1855 3030 1855 3105 { lab=Vg}
N 1370 3000 1370 3030 { lab=VLX}
N 1505 3000 1505 3030 { lab=VLX}
N 1655 3000 1655 3030 { lab=VLX}
N 1815 3000 1815 3030 { lab=VLX}
N 1975 3000 1975 3030 { lab=VLX}
N 1235 3000 1370 3000 { lab=VLX}
N 1235 3060 1370 3060 { lab=Vout}
N 1275 3105 1410 3105 { lab=Vg}
N 2125 3000 2260 3000 { lab=VLX}
N 2260 3000 2410 3000 { lab=VLX}
N 2410 3000 2570 3000 { lab=VLX}
N 2570 3000 2730 3000 { lab=VLX}
N 2125 3060 2260 3060 { lab=Vout}
N 2260 3060 2410 3060 { lab=Vout}
N 2410 3060 2570 3060 { lab=Vout}
N 2570 3060 2730 3060 { lab=Vout}
N 2165 3030 2165 3105 { lab=Vg}
N 2165 3105 2300 3105 { lab=Vg}
N 2300 3030 2300 3105 { lab=Vg}
N 2300 3105 2455 3105 { lab=Vg}
N 2770 3030 2770 3105 { lab=Vg}
N 2455 3105 2770 3105 { lab=Vg}
N 2450 3030 2450 3105 { lab=Vg}
N 2610 3030 2610 3105 { lab=Vg}
N 2125 3000 2125 3030 { lab=VLX}
N 2260 3000 2260 3030 { lab=VLX}
N 2410 3000 2410 3030 { lab=VLX}
N 2570 3000 2570 3030 { lab=VLX}
N 2730 3000 2730 3030 { lab=VLX}
N 2865 3000 3000 3000 { lab=VLX}
N 3000 3000 3150 3000 { lab=VLX}
N 3150 3000 3310 3000 { lab=VLX}
N 3310 3000 3470 3000 { lab=VLX}
N 2865 3060 3000 3060 { lab=Vout}
N 3000 3060 3150 3060 { lab=Vout}
N 3150 3060 3310 3060 { lab=Vout}
N 3310 3060 3470 3060 { lab=Vout}
N 2905 3030 2905 3105 { lab=Vg}
N 2905 3105 3040 3105 { lab=Vg}
N 3040 3030 3040 3105 { lab=Vg}
N 3040 3105 3195 3105 { lab=Vg}
N 3510 3030 3510 3105 { lab=Vg}
N 3195 3105 3510 3105 { lab=Vg}
N 3190 3030 3190 3105 { lab=Vg}
N 3350 3030 3350 3105 { lab=Vg}
N 2865 3000 2865 3030 { lab=VLX}
N 3000 3000 3000 3030 { lab=VLX}
N 3150 3000 3150 3030 { lab=VLX}
N 3310 3000 3310 3030 { lab=VLX}
N 3470 3000 3470 3030 { lab=VLX}
N 2730 3000 2865 3000 { lab=VLX}
N 2730 3060 2865 3060 { lab=Vout}
N 2770 3105 2905 3105 { lab=Vg}
N 1975 3000 2125 3000 { lab=VLX}
N 2015 3105 2165 3105 { lab=Vg}
N 1975 3060 2125 3060 { lab=Vout}
N 3510 2940 3510 3030 { lab=Vg}
N 385 2835 630 2835 { lab=VLX}
N 380 3000 630 3000 { lab=VLX}
N 380 2835 380 3000 { lab=VLX}
N 380 2835 385 2835 { lab=VLX}
N 500 2895 500 3105 { lab=Vout}
N 380 2650 380 2840 { lab=VLX}
N 500 2750 500 2900 { lab=Vout}
N 3510 2750 3510 2870 { lab=Vg}
N 380 2330 380 2490 { lab=VLX}
N 500 2430 500 2550 { lab=Vout}
N 3510 2440 3510 2510 { lab=Vg}
N 3510 2430 3510 2440 { lab=Vg}
N 3510 1680 3510 1850 { lab=Vg}
N 500 1680 500 1890 { lab=Vout}
N 380 1580 380 1820 { lab=VLX}
N 3510 240 3510 430 { lab=Vg}
N 500 230 500 460 { lab=Vout}
N 380 140 380 400 { lab=VLX}
N 650 3355 785 3355 { lab=VLX}
N 785 3355 935 3355 { lab=VLX}
N 935 3355 1095 3355 { lab=VLX}
N 1095 3355 1255 3355 { lab=VLX}
N 650 3415 785 3415 { lab=Vout}
N 785 3415 935 3415 { lab=Vout}
N 935 3415 1095 3415 { lab=Vout}
N 1095 3415 1255 3415 { lab=Vout}
N 690 3385 690 3460 { lab=Vg}
N 690 3460 825 3460 { lab=Vg}
N 825 3385 825 3460 { lab=Vg}
N 825 3460 980 3460 { lab=Vg}
N 1295 3385 1295 3460 { lab=Vg}
N 980 3460 1295 3460 { lab=Vg}
N 975 3385 975 3460 { lab=Vg}
N 1135 3385 1135 3460 { lab=Vg}
N 650 3355 650 3385 { lab=VLX}
N 785 3355 785 3385 { lab=VLX}
N 935 3355 935 3385 { lab=VLX}
N 1095 3355 1095 3385 { lab=VLX}
N 1255 3355 1255 3385 { lab=VLX}
N 1390 3355 1525 3355 { lab=VLX}
N 1525 3355 1675 3355 { lab=VLX}
N 1675 3355 1835 3355 { lab=VLX}
N 1835 3355 1995 3355 { lab=VLX}
N 1390 3415 1525 3415 { lab=Vout}
N 1525 3415 1675 3415 { lab=Vout}
N 1675 3415 1835 3415 { lab=Vout}
N 1835 3415 1995 3415 { lab=Vout}
N 1430 3385 1430 3460 { lab=Vg}
N 1430 3460 1565 3460 { lab=Vg}
N 1565 3385 1565 3460 { lab=Vg}
N 1565 3460 1720 3460 { lab=Vg}
N 2035 3385 2035 3460 { lab=Vg}
N 1720 3460 2035 3460 { lab=Vg}
N 1715 3385 1715 3460 { lab=Vg}
N 1875 3385 1875 3460 { lab=Vg}
N 1390 3355 1390 3385 { lab=VLX}
N 1525 3355 1525 3385 { lab=VLX}
N 1675 3355 1675 3385 { lab=VLX}
N 1835 3355 1835 3385 { lab=VLX}
N 1995 3355 1995 3385 { lab=VLX}
N 1255 3355 1390 3355 { lab=VLX}
N 1255 3415 1390 3415 { lab=Vout}
N 1295 3460 1430 3460 { lab=Vg}
N 2145 3355 2280 3355 { lab=VLX}
N 2280 3355 2430 3355 { lab=VLX}
N 2430 3355 2590 3355 { lab=VLX}
N 2590 3355 2750 3355 { lab=VLX}
N 2145 3415 2280 3415 { lab=Vout}
N 2280 3415 2430 3415 { lab=Vout}
N 2430 3415 2590 3415 { lab=Vout}
N 2590 3415 2750 3415 { lab=Vout}
N 2185 3385 2185 3460 { lab=Vg}
N 2185 3460 2320 3460 { lab=Vg}
N 2320 3385 2320 3460 { lab=Vg}
N 2320 3460 2475 3460 { lab=Vg}
N 2790 3385 2790 3460 { lab=Vg}
N 2475 3460 2790 3460 { lab=Vg}
N 2470 3385 2470 3460 { lab=Vg}
N 2630 3385 2630 3460 { lab=Vg}
N 2145 3355 2145 3385 { lab=VLX}
N 2280 3355 2280 3385 { lab=VLX}
N 2430 3355 2430 3385 { lab=VLX}
N 2590 3355 2590 3385 { lab=VLX}
N 2750 3355 2750 3385 { lab=VLX}
N 2885 3355 3020 3355 { lab=VLX}
N 3020 3355 3170 3355 { lab=VLX}
N 3170 3355 3330 3355 { lab=VLX}
N 3330 3355 3490 3355 { lab=VLX}
N 2885 3415 3020 3415 { lab=Vout}
N 3020 3415 3170 3415 { lab=Vout}
N 3170 3415 3330 3415 { lab=Vout}
N 3330 3415 3490 3415 { lab=Vout}
N 2925 3385 2925 3460 { lab=Vg}
N 2925 3460 3060 3460 { lab=Vg}
N 3060 3385 3060 3460 { lab=Vg}
N 3060 3460 3215 3460 { lab=Vg}
N 3530 3385 3530 3460 { lab=Vg}
N 3215 3460 3530 3460 { lab=Vg}
N 3210 3385 3210 3460 { lab=Vg}
N 3370 3385 3370 3460 { lab=Vg}
N 2885 3355 2885 3385 { lab=VLX}
N 3020 3355 3020 3385 { lab=VLX}
N 3170 3355 3170 3385 { lab=VLX}
N 3330 3355 3330 3385 { lab=VLX}
N 3490 3355 3490 3385 { lab=VLX}
N 2750 3355 2885 3355 { lab=VLX}
N 2750 3415 2885 3415 { lab=Vout}
N 2790 3460 2925 3460 { lab=Vg}
N 1995 3355 2145 3355 { lab=VLX}
N 2035 3460 2185 3460 { lab=Vg}
N 1995 3415 2145 3415 { lab=Vout}
N 650 3520 785 3520 { lab=VLX}
N 785 3520 935 3520 { lab=VLX}
N 935 3520 1095 3520 { lab=VLX}
N 1095 3520 1255 3520 { lab=VLX}
N 650 3580 785 3580 { lab=Vout}
N 785 3580 935 3580 { lab=Vout}
N 935 3580 1095 3580 { lab=Vout}
N 1095 3580 1255 3580 { lab=Vout}
N 690 3550 690 3625 { lab=Vg}
N 690 3625 825 3625 { lab=Vg}
N 825 3550 825 3625 { lab=Vg}
N 825 3625 980 3625 { lab=Vg}
N 1295 3550 1295 3625 { lab=Vg}
N 980 3625 1295 3625 { lab=Vg}
N 975 3550 975 3625 { lab=Vg}
N 1135 3550 1135 3625 { lab=Vg}
N 650 3520 650 3550 { lab=VLX}
N 785 3520 785 3550 { lab=VLX}
N 935 3520 935 3550 { lab=VLX}
N 1095 3520 1095 3550 { lab=VLX}
N 1255 3520 1255 3550 { lab=VLX}
N 1390 3520 1525 3520 { lab=VLX}
N 1525 3520 1675 3520 { lab=VLX}
N 1675 3520 1835 3520 { lab=VLX}
N 1835 3520 1995 3520 { lab=VLX}
N 1390 3580 1525 3580 { lab=Vout}
N 1525 3580 1675 3580 { lab=Vout}
N 1675 3580 1835 3580 { lab=Vout}
N 1835 3580 1995 3580 { lab=Vout}
N 1430 3550 1430 3625 { lab=Vg}
N 1430 3625 1565 3625 { lab=Vg}
N 1565 3550 1565 3625 { lab=Vg}
N 1565 3625 1720 3625 { lab=Vg}
N 2035 3550 2035 3625 { lab=Vg}
N 1720 3625 2035 3625 { lab=Vg}
N 1715 3550 1715 3625 { lab=Vg}
N 1875 3550 1875 3625 { lab=Vg}
N 1390 3520 1390 3550 { lab=VLX}
N 1525 3520 1525 3550 { lab=VLX}
N 1675 3520 1675 3550 { lab=VLX}
N 1835 3520 1835 3550 { lab=VLX}
N 1995 3520 1995 3550 { lab=VLX}
N 1255 3520 1390 3520 { lab=VLX}
N 1255 3580 1390 3580 { lab=Vout}
N 1295 3625 1430 3625 { lab=Vg}
N 2145 3520 2280 3520 { lab=VLX}
N 2280 3520 2430 3520 { lab=VLX}
N 2430 3520 2590 3520 { lab=VLX}
N 2590 3520 2750 3520 { lab=VLX}
N 2145 3580 2280 3580 { lab=Vout}
N 2280 3580 2430 3580 { lab=Vout}
N 2430 3580 2590 3580 { lab=Vout}
N 2590 3580 2750 3580 { lab=Vout}
N 2185 3550 2185 3625 { lab=Vg}
N 2185 3625 2320 3625 { lab=Vg}
N 2320 3550 2320 3625 { lab=Vg}
N 2320 3625 2475 3625 { lab=Vg}
N 2790 3550 2790 3625 { lab=Vg}
N 2475 3625 2790 3625 { lab=Vg}
N 2470 3550 2470 3625 { lab=Vg}
N 2630 3550 2630 3625 { lab=Vg}
N 2145 3520 2145 3550 { lab=VLX}
N 2280 3520 2280 3550 { lab=VLX}
N 2430 3520 2430 3550 { lab=VLX}
N 2590 3520 2590 3550 { lab=VLX}
N 2750 3520 2750 3550 { lab=VLX}
N 2885 3520 3020 3520 { lab=VLX}
N 3020 3520 3170 3520 { lab=VLX}
N 3170 3520 3330 3520 { lab=VLX}
N 3330 3520 3490 3520 { lab=VLX}
N 2885 3580 3020 3580 { lab=Vout}
N 3020 3580 3170 3580 { lab=Vout}
N 3170 3580 3330 3580 { lab=Vout}
N 3330 3580 3490 3580 { lab=Vout}
N 2925 3550 2925 3625 { lab=Vg}
N 2925 3625 3060 3625 { lab=Vg}
N 3060 3550 3060 3625 { lab=Vg}
N 3060 3625 3215 3625 { lab=Vg}
N 3530 3550 3530 3625 { lab=Vg}
N 3215 3625 3530 3625 { lab=Vg}
N 3210 3550 3210 3625 { lab=Vg}
N 3370 3550 3370 3625 { lab=Vg}
N 2885 3520 2885 3550 { lab=VLX}
N 3020 3520 3020 3550 { lab=VLX}
N 3170 3520 3170 3550 { lab=VLX}
N 3330 3520 3330 3550 { lab=VLX}
N 3490 3520 3490 3550 { lab=VLX}
N 2750 3520 2885 3520 { lab=VLX}
N 2750 3580 2885 3580 { lab=Vout}
N 2790 3625 2925 3625 { lab=Vg}
N 1995 3520 2145 3520 { lab=VLX}
N 2035 3625 2185 3625 { lab=Vg}
N 1995 3580 2145 3580 { lab=Vout}
N 3530 3460 3530 3550 { lab=Vg}
N 405 3355 650 3355 { lab=VLX}
N 400 3520 650 3520 { lab=VLX}
N 400 3355 400 3520 { lab=VLX}
N 400 3355 405 3355 { lab=VLX}
N 520 3415 520 3625 { lab=Vout}
N 650 3705 785 3705 { lab=VLX}
N 785 3705 935 3705 { lab=VLX}
N 935 3705 1095 3705 { lab=VLX}
N 1095 3705 1255 3705 { lab=VLX}
N 650 3765 785 3765 { lab=Vout}
N 785 3765 935 3765 { lab=Vout}
N 935 3765 1095 3765 { lab=Vout}
N 1095 3765 1255 3765 { lab=Vout}
N 690 3735 690 3810 { lab=Vg}
N 690 3810 825 3810 { lab=Vg}
N 825 3735 825 3810 { lab=Vg}
N 825 3810 980 3810 { lab=Vg}
N 1295 3735 1295 3810 { lab=Vg}
N 980 3810 1295 3810 { lab=Vg}
N 975 3735 975 3810 { lab=Vg}
N 1135 3735 1135 3810 { lab=Vg}
N 650 3705 650 3735 { lab=VLX}
N 785 3705 785 3735 { lab=VLX}
N 935 3705 935 3735 { lab=VLX}
N 1095 3705 1095 3735 { lab=VLX}
N 1255 3705 1255 3735 { lab=VLX}
N 1390 3705 1525 3705 { lab=VLX}
N 1525 3705 1675 3705 { lab=VLX}
N 1675 3705 1835 3705 { lab=VLX}
N 1835 3705 1995 3705 { lab=VLX}
N 1390 3765 1525 3765 { lab=Vout}
N 1525 3765 1675 3765 { lab=Vout}
N 1675 3765 1835 3765 { lab=Vout}
N 1835 3765 1995 3765 { lab=Vout}
N 1430 3735 1430 3810 { lab=Vg}
N 1430 3810 1565 3810 { lab=Vg}
N 1565 3735 1565 3810 { lab=Vg}
N 1565 3810 1720 3810 { lab=Vg}
N 2035 3735 2035 3810 { lab=Vg}
N 1720 3810 2035 3810 { lab=Vg}
N 1715 3735 1715 3810 { lab=Vg}
N 1875 3735 1875 3810 { lab=Vg}
N 1390 3705 1390 3735 { lab=VLX}
N 1525 3705 1525 3735 { lab=VLX}
N 1675 3705 1675 3735 { lab=VLX}
N 1835 3705 1835 3735 { lab=VLX}
N 1995 3705 1995 3735 { lab=VLX}
N 1255 3705 1390 3705 { lab=VLX}
N 1255 3765 1390 3765 { lab=Vout}
N 1295 3810 1430 3810 { lab=Vg}
N 2145 3705 2280 3705 { lab=VLX}
N 2280 3705 2430 3705 { lab=VLX}
N 2430 3705 2590 3705 { lab=VLX}
N 2590 3705 2750 3705 { lab=VLX}
N 2145 3765 2280 3765 { lab=Vout}
N 2280 3765 2430 3765 { lab=Vout}
N 2430 3765 2590 3765 { lab=Vout}
N 2590 3765 2750 3765 { lab=Vout}
N 2185 3735 2185 3810 { lab=Vg}
N 2185 3810 2320 3810 { lab=Vg}
N 2320 3735 2320 3810 { lab=Vg}
N 2320 3810 2475 3810 { lab=Vg}
N 2790 3735 2790 3810 { lab=Vg}
N 2475 3810 2790 3810 { lab=Vg}
N 2470 3735 2470 3810 { lab=Vg}
N 2630 3735 2630 3810 { lab=Vg}
N 2145 3705 2145 3735 { lab=VLX}
N 2280 3705 2280 3735 { lab=VLX}
N 2430 3705 2430 3735 { lab=VLX}
N 2590 3705 2590 3735 { lab=VLX}
N 2750 3705 2750 3735 { lab=VLX}
N 2885 3705 3020 3705 { lab=VLX}
N 3020 3705 3170 3705 { lab=VLX}
N 3170 3705 3330 3705 { lab=VLX}
N 3330 3705 3490 3705 { lab=VLX}
N 2885 3765 3020 3765 { lab=Vout}
N 3020 3765 3170 3765 { lab=Vout}
N 3170 3765 3330 3765 { lab=Vout}
N 3330 3765 3490 3765 { lab=Vout}
N 2925 3735 2925 3810 { lab=Vg}
N 2925 3810 3060 3810 { lab=Vg}
N 3060 3735 3060 3810 { lab=Vg}
N 3060 3810 3215 3810 { lab=Vg}
N 3530 3735 3530 3810 { lab=Vg}
N 3215 3810 3530 3810 { lab=Vg}
N 3210 3735 3210 3810 { lab=Vg}
N 3370 3735 3370 3810 { lab=Vg}
N 2885 3705 2885 3735 { lab=VLX}
N 3020 3705 3020 3735 { lab=VLX}
N 3170 3705 3170 3735 { lab=VLX}
N 3330 3705 3330 3735 { lab=VLX}
N 3490 3705 3490 3735 { lab=VLX}
N 2750 3705 2885 3705 { lab=VLX}
N 2750 3765 2885 3765 { lab=Vout}
N 2790 3810 2925 3810 { lab=Vg}
N 1995 3705 2145 3705 { lab=VLX}
N 2035 3810 2185 3810 { lab=Vg}
N 1995 3765 2145 3765 { lab=Vout}
N 650 3870 785 3870 { lab=VLX}
N 785 3870 935 3870 { lab=VLX}
N 935 3870 1095 3870 { lab=VLX}
N 1095 3870 1255 3870 { lab=VLX}
N 650 3930 785 3930 { lab=Vout}
N 785 3930 935 3930 { lab=Vout}
N 935 3930 1095 3930 { lab=Vout}
N 1095 3930 1255 3930 { lab=Vout}
N 690 3900 690 3975 { lab=Vg}
N 690 3975 825 3975 { lab=Vg}
N 825 3900 825 3975 { lab=Vg}
N 825 3975 980 3975 { lab=Vg}
N 1295 3900 1295 3975 { lab=Vg}
N 980 3975 1295 3975 { lab=Vg}
N 975 3900 975 3975 { lab=Vg}
N 1135 3900 1135 3975 { lab=Vg}
N 650 3870 650 3900 { lab=VLX}
N 785 3870 785 3900 { lab=VLX}
N 935 3870 935 3900 { lab=VLX}
N 1095 3870 1095 3900 { lab=VLX}
N 1255 3870 1255 3900 { lab=VLX}
N 1390 3870 1525 3870 { lab=VLX}
N 1525 3870 1675 3870 { lab=VLX}
N 1675 3870 1835 3870 { lab=VLX}
N 1835 3870 1995 3870 { lab=VLX}
N 1390 3930 1525 3930 { lab=Vout}
N 1525 3930 1675 3930 { lab=Vout}
N 1675 3930 1835 3930 { lab=Vout}
N 1835 3930 1995 3930 { lab=Vout}
N 1430 3900 1430 3975 { lab=Vg}
N 1430 3975 1565 3975 { lab=Vg}
N 1565 3900 1565 3975 { lab=Vg}
N 1565 3975 1720 3975 { lab=Vg}
N 2035 3900 2035 3975 { lab=Vg}
N 1720 3975 2035 3975 { lab=Vg}
N 1715 3900 1715 3975 { lab=Vg}
N 1875 3900 1875 3975 { lab=Vg}
N 1390 3870 1390 3900 { lab=VLX}
N 1525 3870 1525 3900 { lab=VLX}
N 1675 3870 1675 3900 { lab=VLX}
N 1835 3870 1835 3900 { lab=VLX}
N 1995 3870 1995 3900 { lab=VLX}
N 1255 3870 1390 3870 { lab=VLX}
N 1255 3930 1390 3930 { lab=Vout}
N 1295 3975 1430 3975 { lab=Vg}
N 2145 3870 2280 3870 { lab=VLX}
N 2280 3870 2430 3870 { lab=VLX}
N 2430 3870 2590 3870 { lab=VLX}
N 2590 3870 2750 3870 { lab=VLX}
N 2145 3930 2280 3930 { lab=Vout}
N 2280 3930 2430 3930 { lab=Vout}
N 2430 3930 2590 3930 { lab=Vout}
N 2590 3930 2750 3930 { lab=Vout}
N 2185 3900 2185 3975 { lab=Vg}
N 2185 3975 2320 3975 { lab=Vg}
N 2320 3900 2320 3975 { lab=Vg}
N 2320 3975 2475 3975 { lab=Vg}
N 2790 3900 2790 3975 { lab=Vg}
N 2475 3975 2790 3975 { lab=Vg}
N 2470 3900 2470 3975 { lab=Vg}
N 2630 3900 2630 3975 { lab=Vg}
N 2145 3870 2145 3900 { lab=VLX}
N 2280 3870 2280 3900 { lab=VLX}
N 2430 3870 2430 3900 { lab=VLX}
N 2590 3870 2590 3900 { lab=VLX}
N 2750 3870 2750 3900 { lab=VLX}
N 2885 3870 3020 3870 { lab=VLX}
N 3020 3870 3170 3870 { lab=VLX}
N 3170 3870 3330 3870 { lab=VLX}
N 3330 3870 3490 3870 { lab=VLX}
N 2885 3930 3020 3930 { lab=Vout}
N 3020 3930 3170 3930 { lab=Vout}
N 3170 3930 3330 3930 { lab=Vout}
N 3330 3930 3490 3930 { lab=Vout}
N 2925 3900 2925 3975 { lab=Vg}
N 2925 3975 3060 3975 { lab=Vg}
N 3060 3900 3060 3975 { lab=Vg}
N 3060 3975 3215 3975 { lab=Vg}
N 3530 3900 3530 3975 { lab=Vg}
N 3215 3975 3530 3975 { lab=Vg}
N 3210 3900 3210 3975 { lab=Vg}
N 3370 3900 3370 3975 { lab=Vg}
N 2885 3870 2885 3900 { lab=VLX}
N 3020 3870 3020 3900 { lab=VLX}
N 3170 3870 3170 3900 { lab=VLX}
N 3330 3870 3330 3900 { lab=VLX}
N 3490 3870 3490 3900 { lab=VLX}
N 2750 3870 2885 3870 { lab=VLX}
N 2750 3930 2885 3930 { lab=Vout}
N 2790 3975 2925 3975 { lab=Vg}
N 1995 3870 2145 3870 { lab=VLX}
N 2035 3975 2185 3975 { lab=Vg}
N 1995 3930 2145 3930 { lab=Vout}
N 3530 3810 3530 3900 { lab=Vg}
N 405 3705 650 3705 { lab=VLX}
N 400 3870 650 3870 { lab=VLX}
N 400 3705 400 3870 { lab=VLX}
N 400 3705 405 3705 { lab=VLX}
N 520 3765 520 3975 { lab=Vout}
N 400 3520 400 3710 { lab=VLX}
N 520 3620 520 3770 { lab=Vout}
N 3530 3620 3530 3740 { lab=Vg}
N 650 4025 785 4025 { lab=VLX}
N 785 4025 935 4025 { lab=VLX}
N 935 4025 1095 4025 { lab=VLX}
N 1095 4025 1255 4025 { lab=VLX}
N 650 4085 785 4085 { lab=Vout}
N 785 4085 935 4085 { lab=Vout}
N 935 4085 1095 4085 { lab=Vout}
N 1095 4085 1255 4085 { lab=Vout}
N 690 4055 690 4130 { lab=Vg}
N 690 4130 825 4130 { lab=Vg}
N 825 4055 825 4130 { lab=Vg}
N 825 4130 980 4130 { lab=Vg}
N 1295 4055 1295 4130 { lab=Vg}
N 980 4130 1295 4130 { lab=Vg}
N 975 4055 975 4130 { lab=Vg}
N 1135 4055 1135 4130 { lab=Vg}
N 650 4025 650 4055 { lab=VLX}
N 785 4025 785 4055 { lab=VLX}
N 935 4025 935 4055 { lab=VLX}
N 1095 4025 1095 4055 { lab=VLX}
N 1255 4025 1255 4055 { lab=VLX}
N 1390 4025 1525 4025 { lab=VLX}
N 1525 4025 1675 4025 { lab=VLX}
N 1675 4025 1835 4025 { lab=VLX}
N 1835 4025 1995 4025 { lab=VLX}
N 1390 4085 1525 4085 { lab=Vout}
N 1525 4085 1675 4085 { lab=Vout}
N 1675 4085 1835 4085 { lab=Vout}
N 1835 4085 1995 4085 { lab=Vout}
N 1430 4055 1430 4130 { lab=Vg}
N 1430 4130 1565 4130 { lab=Vg}
N 1565 4055 1565 4130 { lab=Vg}
N 1565 4130 1720 4130 { lab=Vg}
N 2035 4055 2035 4130 { lab=Vg}
N 1720 4130 2035 4130 { lab=Vg}
N 1715 4055 1715 4130 { lab=Vg}
N 1875 4055 1875 4130 { lab=Vg}
N 1390 4025 1390 4055 { lab=VLX}
N 1525 4025 1525 4055 { lab=VLX}
N 1675 4025 1675 4055 { lab=VLX}
N 1835 4025 1835 4055 { lab=VLX}
N 1995 4025 1995 4055 { lab=VLX}
N 1255 4025 1390 4025 { lab=VLX}
N 1255 4085 1390 4085 { lab=Vout}
N 1295 4130 1430 4130 { lab=Vg}
N 2145 4025 2280 4025 { lab=VLX}
N 2280 4025 2430 4025 { lab=VLX}
N 2430 4025 2590 4025 { lab=VLX}
N 2590 4025 2750 4025 { lab=VLX}
N 2145 4085 2280 4085 { lab=Vout}
N 2280 4085 2430 4085 { lab=Vout}
N 2430 4085 2590 4085 { lab=Vout}
N 2590 4085 2750 4085 { lab=Vout}
N 2185 4055 2185 4130 { lab=Vg}
N 2185 4130 2320 4130 { lab=Vg}
N 2320 4055 2320 4130 { lab=Vg}
N 2320 4130 2475 4130 { lab=Vg}
N 2790 4055 2790 4130 { lab=Vg}
N 2475 4130 2790 4130 { lab=Vg}
N 2470 4055 2470 4130 { lab=Vg}
N 2630 4055 2630 4130 { lab=Vg}
N 2145 4025 2145 4055 { lab=VLX}
N 2280 4025 2280 4055 { lab=VLX}
N 2430 4025 2430 4055 { lab=VLX}
N 2590 4025 2590 4055 { lab=VLX}
N 2750 4025 2750 4055 { lab=VLX}
N 2885 4025 3020 4025 { lab=VLX}
N 3020 4025 3170 4025 { lab=VLX}
N 3170 4025 3330 4025 { lab=VLX}
N 3330 4025 3490 4025 { lab=VLX}
N 2885 4085 3020 4085 { lab=Vout}
N 3020 4085 3170 4085 { lab=Vout}
N 3170 4085 3330 4085 { lab=Vout}
N 3330 4085 3490 4085 { lab=Vout}
N 2925 4055 2925 4130 { lab=Vg}
N 2925 4130 3060 4130 { lab=Vg}
N 3060 4055 3060 4130 { lab=Vg}
N 3060 4130 3215 4130 { lab=Vg}
N 3530 4055 3530 4130 { lab=Vg}
N 3215 4130 3530 4130 { lab=Vg}
N 3210 4055 3210 4130 { lab=Vg}
N 3370 4055 3370 4130 { lab=Vg}
N 2885 4025 2885 4055 { lab=VLX}
N 3020 4025 3020 4055 { lab=VLX}
N 3170 4025 3170 4055 { lab=VLX}
N 3330 4025 3330 4055 { lab=VLX}
N 3490 4025 3490 4055 { lab=VLX}
N 2750 4025 2885 4025 { lab=VLX}
N 2750 4085 2885 4085 { lab=Vout}
N 2790 4130 2925 4130 { lab=Vg}
N 1995 4025 2145 4025 { lab=VLX}
N 2035 4130 2185 4130 { lab=Vg}
N 1995 4085 2145 4085 { lab=Vout}
N 650 4190 785 4190 { lab=VLX}
N 785 4190 935 4190 { lab=VLX}
N 935 4190 1095 4190 { lab=VLX}
N 1095 4190 1255 4190 { lab=VLX}
N 650 4250 785 4250 { lab=Vout}
N 785 4250 935 4250 { lab=Vout}
N 935 4250 1095 4250 { lab=Vout}
N 1095 4250 1255 4250 { lab=Vout}
N 690 4220 690 4295 { lab=Vg}
N 690 4295 825 4295 { lab=Vg}
N 825 4220 825 4295 { lab=Vg}
N 825 4295 980 4295 { lab=Vg}
N 1295 4220 1295 4295 { lab=Vg}
N 980 4295 1295 4295 { lab=Vg}
N 975 4220 975 4295 { lab=Vg}
N 1135 4220 1135 4295 { lab=Vg}
N 650 4190 650 4220 { lab=VLX}
N 785 4190 785 4220 { lab=VLX}
N 935 4190 935 4220 { lab=VLX}
N 1095 4190 1095 4220 { lab=VLX}
N 1255 4190 1255 4220 { lab=VLX}
N 1390 4190 1525 4190 { lab=VLX}
N 1525 4190 1675 4190 { lab=VLX}
N 1675 4190 1835 4190 { lab=VLX}
N 1835 4190 1995 4190 { lab=VLX}
N 1390 4250 1525 4250 { lab=Vout}
N 1525 4250 1675 4250 { lab=Vout}
N 1675 4250 1835 4250 { lab=Vout}
N 1835 4250 1995 4250 { lab=Vout}
N 1430 4220 1430 4295 { lab=Vg}
N 1430 4295 1565 4295 { lab=Vg}
N 1565 4220 1565 4295 { lab=Vg}
N 1565 4295 1720 4295 { lab=Vg}
N 2035 4220 2035 4295 { lab=Vg}
N 1720 4295 2035 4295 { lab=Vg}
N 1715 4220 1715 4295 { lab=Vg}
N 1875 4220 1875 4295 { lab=Vg}
N 1390 4190 1390 4220 { lab=VLX}
N 1525 4190 1525 4220 { lab=VLX}
N 1675 4190 1675 4220 { lab=VLX}
N 1835 4190 1835 4220 { lab=VLX}
N 1995 4190 1995 4220 { lab=VLX}
N 1255 4190 1390 4190 { lab=VLX}
N 1255 4250 1390 4250 { lab=Vout}
N 1295 4295 1430 4295 { lab=Vg}
N 2145 4190 2280 4190 { lab=VLX}
N 2280 4190 2430 4190 { lab=VLX}
N 2430 4190 2590 4190 { lab=VLX}
N 2590 4190 2750 4190 { lab=VLX}
N 2145 4250 2280 4250 { lab=Vout}
N 2280 4250 2430 4250 { lab=Vout}
N 2430 4250 2590 4250 { lab=Vout}
N 2590 4250 2750 4250 { lab=Vout}
N 2185 4220 2185 4295 { lab=Vg}
N 2185 4295 2320 4295 { lab=Vg}
N 2320 4220 2320 4295 { lab=Vg}
N 2320 4295 2475 4295 { lab=Vg}
N 2790 4220 2790 4295 { lab=Vg}
N 2475 4295 2790 4295 { lab=Vg}
N 2470 4220 2470 4295 { lab=Vg}
N 2630 4220 2630 4295 { lab=Vg}
N 2145 4190 2145 4220 { lab=VLX}
N 2280 4190 2280 4220 { lab=VLX}
N 2430 4190 2430 4220 { lab=VLX}
N 2590 4190 2590 4220 { lab=VLX}
N 2750 4190 2750 4220 { lab=VLX}
N 2885 4190 3020 4190 { lab=VLX}
N 3020 4190 3170 4190 { lab=VLX}
N 3170 4190 3330 4190 { lab=VLX}
N 3330 4190 3490 4190 { lab=VLX}
N 2885 4250 3020 4250 { lab=Vout}
N 3020 4250 3170 4250 { lab=Vout}
N 3170 4250 3330 4250 { lab=Vout}
N 3330 4250 3490 4250 { lab=Vout}
N 2925 4220 2925 4295 { lab=Vg}
N 2925 4295 3060 4295 { lab=Vg}
N 3060 4220 3060 4295 { lab=Vg}
N 3060 4295 3215 4295 { lab=Vg}
N 3530 4220 3530 4295 { lab=Vg}
N 3215 4295 3530 4295 { lab=Vg}
N 3210 4220 3210 4295 { lab=Vg}
N 3370 4220 3370 4295 { lab=Vg}
N 2885 4190 2885 4220 { lab=VLX}
N 3020 4190 3020 4220 { lab=VLX}
N 3170 4190 3170 4220 { lab=VLX}
N 3330 4190 3330 4220 { lab=VLX}
N 3490 4190 3490 4220 { lab=VLX}
N 2750 4190 2885 4190 { lab=VLX}
N 2750 4250 2885 4250 { lab=Vout}
N 2790 4295 2925 4295 { lab=Vg}
N 1995 4190 2145 4190 { lab=VLX}
N 2035 4295 2185 4295 { lab=Vg}
N 1995 4250 2145 4250 { lab=Vout}
N 3530 4130 3530 4220 { lab=Vg}
N 405 4025 650 4025 { lab=VLX}
N 400 4190 650 4190 { lab=VLX}
N 400 4025 400 4190 { lab=VLX}
N 400 4025 405 4025 { lab=VLX}
N 520 4085 520 4295 { lab=Vout}
N 650 4375 785 4375 { lab=VLX}
N 785 4375 935 4375 { lab=VLX}
N 935 4375 1095 4375 { lab=VLX}
N 1095 4375 1255 4375 { lab=VLX}
N 650 4435 785 4435 { lab=Vout}
N 785 4435 935 4435 { lab=Vout}
N 935 4435 1095 4435 { lab=Vout}
N 1095 4435 1255 4435 { lab=Vout}
N 690 4405 690 4480 { lab=Vg}
N 690 4480 825 4480 { lab=Vg}
N 825 4405 825 4480 { lab=Vg}
N 825 4480 980 4480 { lab=Vg}
N 1295 4405 1295 4480 { lab=Vg}
N 980 4480 1295 4480 { lab=Vg}
N 975 4405 975 4480 { lab=Vg}
N 1135 4405 1135 4480 { lab=Vg}
N 650 4375 650 4405 { lab=VLX}
N 785 4375 785 4405 { lab=VLX}
N 935 4375 935 4405 { lab=VLX}
N 1095 4375 1095 4405 { lab=VLX}
N 1255 4375 1255 4405 { lab=VLX}
N 1390 4375 1525 4375 { lab=VLX}
N 1525 4375 1675 4375 { lab=VLX}
N 1675 4375 1835 4375 { lab=VLX}
N 1835 4375 1995 4375 { lab=VLX}
N 1390 4435 1525 4435 { lab=Vout}
N 1525 4435 1675 4435 { lab=Vout}
N 1675 4435 1835 4435 { lab=Vout}
N 1835 4435 1995 4435 { lab=Vout}
N 1430 4405 1430 4480 { lab=Vg}
N 1430 4480 1565 4480 { lab=Vg}
N 1565 4405 1565 4480 { lab=Vg}
N 1565 4480 1720 4480 { lab=Vg}
N 2035 4405 2035 4480 { lab=Vg}
N 1720 4480 2035 4480 { lab=Vg}
N 1715 4405 1715 4480 { lab=Vg}
N 1875 4405 1875 4480 { lab=Vg}
N 1390 4375 1390 4405 { lab=VLX}
N 1525 4375 1525 4405 { lab=VLX}
N 1675 4375 1675 4405 { lab=VLX}
N 1835 4375 1835 4405 { lab=VLX}
N 1995 4375 1995 4405 { lab=VLX}
N 1255 4375 1390 4375 { lab=VLX}
N 1255 4435 1390 4435 { lab=Vout}
N 1295 4480 1430 4480 { lab=Vg}
N 2145 4375 2280 4375 { lab=VLX}
N 2280 4375 2430 4375 { lab=VLX}
N 2430 4375 2590 4375 { lab=VLX}
N 2590 4375 2750 4375 { lab=VLX}
N 2145 4435 2280 4435 { lab=Vout}
N 2280 4435 2430 4435 { lab=Vout}
N 2430 4435 2590 4435 { lab=Vout}
N 2590 4435 2750 4435 { lab=Vout}
N 2185 4405 2185 4480 { lab=Vg}
N 2185 4480 2320 4480 { lab=Vg}
N 2320 4405 2320 4480 { lab=Vg}
N 2320 4480 2475 4480 { lab=Vg}
N 2790 4405 2790 4480 { lab=Vg}
N 2475 4480 2790 4480 { lab=Vg}
N 2470 4405 2470 4480 { lab=Vg}
N 2630 4405 2630 4480 { lab=Vg}
N 2145 4375 2145 4405 { lab=VLX}
N 2280 4375 2280 4405 { lab=VLX}
N 2430 4375 2430 4405 { lab=VLX}
N 2590 4375 2590 4405 { lab=VLX}
N 2750 4375 2750 4405 { lab=VLX}
N 2885 4375 3020 4375 { lab=VLX}
N 3020 4375 3170 4375 { lab=VLX}
N 3170 4375 3330 4375 { lab=VLX}
N 3330 4375 3490 4375 { lab=VLX}
N 2885 4435 3020 4435 { lab=Vout}
N 3020 4435 3170 4435 { lab=Vout}
N 3170 4435 3330 4435 { lab=Vout}
N 3330 4435 3490 4435 { lab=Vout}
N 2925 4405 2925 4480 { lab=Vg}
N 2925 4480 3060 4480 { lab=Vg}
N 3060 4405 3060 4480 { lab=Vg}
N 3060 4480 3215 4480 { lab=Vg}
N 3530 4405 3530 4480 { lab=Vg}
N 3215 4480 3530 4480 { lab=Vg}
N 3210 4405 3210 4480 { lab=Vg}
N 3370 4405 3370 4480 { lab=Vg}
N 2885 4375 2885 4405 { lab=VLX}
N 3020 4375 3020 4405 { lab=VLX}
N 3170 4375 3170 4405 { lab=VLX}
N 3330 4375 3330 4405 { lab=VLX}
N 3490 4375 3490 4405 { lab=VLX}
N 2750 4375 2885 4375 { lab=VLX}
N 2750 4435 2885 4435 { lab=Vout}
N 2790 4480 2925 4480 { lab=Vg}
N 1995 4375 2145 4375 { lab=VLX}
N 2035 4480 2185 4480 { lab=Vg}
N 1995 4435 2145 4435 { lab=Vout}
N 650 4540 785 4540 { lab=VLX}
N 785 4540 935 4540 { lab=VLX}
N 935 4540 1095 4540 { lab=VLX}
N 1095 4540 1255 4540 { lab=VLX}
N 650 4600 785 4600 { lab=Vout}
N 785 4600 935 4600 { lab=Vout}
N 935 4600 1095 4600 { lab=Vout}
N 1095 4600 1255 4600 { lab=Vout}
N 690 4570 690 4645 { lab=Vg}
N 690 4645 825 4645 { lab=Vg}
N 825 4570 825 4645 { lab=Vg}
N 825 4645 980 4645 { lab=Vg}
N 1295 4570 1295 4645 { lab=Vg}
N 980 4645 1295 4645 { lab=Vg}
N 975 4570 975 4645 { lab=Vg}
N 1135 4570 1135 4645 { lab=Vg}
N 650 4540 650 4570 { lab=VLX}
N 785 4540 785 4570 { lab=VLX}
N 935 4540 935 4570 { lab=VLX}
N 1095 4540 1095 4570 { lab=VLX}
N 1255 4540 1255 4570 { lab=VLX}
N 1390 4540 1525 4540 { lab=VLX}
N 1525 4540 1675 4540 { lab=VLX}
N 1675 4540 1835 4540 { lab=VLX}
N 1835 4540 1995 4540 { lab=VLX}
N 1390 4600 1525 4600 { lab=Vout}
N 1525 4600 1675 4600 { lab=Vout}
N 1675 4600 1835 4600 { lab=Vout}
N 1835 4600 1995 4600 { lab=Vout}
N 1430 4570 1430 4645 { lab=Vg}
N 1430 4645 1565 4645 { lab=Vg}
N 1565 4570 1565 4645 { lab=Vg}
N 1565 4645 1720 4645 { lab=Vg}
N 2035 4570 2035 4645 { lab=Vg}
N 1720 4645 2035 4645 { lab=Vg}
N 1715 4570 1715 4645 { lab=Vg}
N 1875 4570 1875 4645 { lab=Vg}
N 1390 4540 1390 4570 { lab=VLX}
N 1525 4540 1525 4570 { lab=VLX}
N 1675 4540 1675 4570 { lab=VLX}
N 1835 4540 1835 4570 { lab=VLX}
N 1995 4540 1995 4570 { lab=VLX}
N 1255 4540 1390 4540 { lab=VLX}
N 1255 4600 1390 4600 { lab=Vout}
N 1295 4645 1430 4645 { lab=Vg}
N 2145 4540 2280 4540 { lab=VLX}
N 2280 4540 2430 4540 { lab=VLX}
N 2430 4540 2590 4540 { lab=VLX}
N 2590 4540 2750 4540 { lab=VLX}
N 2145 4600 2280 4600 { lab=Vout}
N 2280 4600 2430 4600 { lab=Vout}
N 2430 4600 2590 4600 { lab=Vout}
N 2590 4600 2750 4600 { lab=Vout}
N 2185 4570 2185 4645 { lab=Vg}
N 2185 4645 2320 4645 { lab=Vg}
N 2320 4570 2320 4645 { lab=Vg}
N 2320 4645 2475 4645 { lab=Vg}
N 2790 4570 2790 4645 { lab=Vg}
N 2475 4645 2790 4645 { lab=Vg}
N 2470 4570 2470 4645 { lab=Vg}
N 2630 4570 2630 4645 { lab=Vg}
N 2145 4540 2145 4570 { lab=VLX}
N 2280 4540 2280 4570 { lab=VLX}
N 2430 4540 2430 4570 { lab=VLX}
N 2590 4540 2590 4570 { lab=VLX}
N 2750 4540 2750 4570 { lab=VLX}
N 2885 4540 3020 4540 { lab=VLX}
N 3020 4540 3170 4540 { lab=VLX}
N 3170 4540 3330 4540 { lab=VLX}
N 3330 4540 3490 4540 { lab=VLX}
N 2885 4600 3020 4600 { lab=Vout}
N 3020 4600 3170 4600 { lab=Vout}
N 3170 4600 3330 4600 { lab=Vout}
N 3330 4600 3490 4600 { lab=Vout}
N 2925 4570 2925 4645 { lab=Vg}
N 2925 4645 3060 4645 { lab=Vg}
N 3060 4570 3060 4645 { lab=Vg}
N 3060 4645 3215 4645 { lab=Vg}
N 3530 4570 3530 4645 { lab=Vg}
N 3215 4645 3530 4645 { lab=Vg}
N 3210 4570 3210 4645 { lab=Vg}
N 3370 4570 3370 4645 { lab=Vg}
N 2885 4540 2885 4570 { lab=VLX}
N 3020 4540 3020 4570 { lab=VLX}
N 3170 4540 3170 4570 { lab=VLX}
N 3330 4540 3330 4570 { lab=VLX}
N 3490 4540 3490 4570 { lab=VLX}
N 2750 4540 2885 4540 { lab=VLX}
N 2750 4600 2885 4600 { lab=Vout}
N 2790 4645 2925 4645 { lab=Vg}
N 1995 4540 2145 4540 { lab=VLX}
N 2035 4645 2185 4645 { lab=Vg}
N 1995 4600 2145 4600 { lab=Vout}
N 3530 4480 3530 4570 { lab=Vg}
N 405 4375 650 4375 { lab=VLX}
N 400 4540 650 4540 { lab=VLX}
N 400 4375 400 4540 { lab=VLX}
N 400 4375 405 4375 { lab=VLX}
N 520 4435 520 4645 { lab=Vout}
N 400 4190 400 4380 { lab=VLX}
N 520 4290 520 4440 { lab=Vout}
N 3530 4290 3530 4410 { lab=Vg}
N 400 3870 400 4030 { lab=VLX}
N 520 3970 520 4090 { lab=Vout}
N 3530 3980 3530 4050 { lab=Vg}
N 3530 3970 3530 3980 { lab=Vg}
N 650 4775 785 4775 { lab=VLX}
N 785 4775 935 4775 { lab=VLX}
N 935 4775 1095 4775 { lab=VLX}
N 1095 4775 1255 4775 { lab=VLX}
N 650 4835 785 4835 { lab=Vout}
N 785 4835 935 4835 { lab=Vout}
N 935 4835 1095 4835 { lab=Vout}
N 1095 4835 1255 4835 { lab=Vout}
N 690 4805 690 4880 { lab=Vg}
N 690 4880 825 4880 { lab=Vg}
N 825 4805 825 4880 { lab=Vg}
N 825 4880 980 4880 { lab=Vg}
N 1295 4805 1295 4880 { lab=Vg}
N 980 4880 1295 4880 { lab=Vg}
N 975 4805 975 4880 { lab=Vg}
N 1135 4805 1135 4880 { lab=Vg}
N 650 4775 650 4805 { lab=VLX}
N 785 4775 785 4805 { lab=VLX}
N 935 4775 935 4805 { lab=VLX}
N 1095 4775 1095 4805 { lab=VLX}
N 1255 4775 1255 4805 { lab=VLX}
N 1390 4775 1525 4775 { lab=VLX}
N 1525 4775 1675 4775 { lab=VLX}
N 1675 4775 1835 4775 { lab=VLX}
N 1835 4775 1995 4775 { lab=VLX}
N 1390 4835 1525 4835 { lab=Vout}
N 1525 4835 1675 4835 { lab=Vout}
N 1675 4835 1835 4835 { lab=Vout}
N 1835 4835 1995 4835 { lab=Vout}
N 1430 4805 1430 4880 { lab=Vg}
N 1430 4880 1565 4880 { lab=Vg}
N 1565 4805 1565 4880 { lab=Vg}
N 1565 4880 1720 4880 { lab=Vg}
N 2035 4805 2035 4880 { lab=Vg}
N 1720 4880 2035 4880 { lab=Vg}
N 1715 4805 1715 4880 { lab=Vg}
N 1875 4805 1875 4880 { lab=Vg}
N 1390 4775 1390 4805 { lab=VLX}
N 1525 4775 1525 4805 { lab=VLX}
N 1675 4775 1675 4805 { lab=VLX}
N 1835 4775 1835 4805 { lab=VLX}
N 1995 4775 1995 4805 { lab=VLX}
N 1255 4775 1390 4775 { lab=VLX}
N 1255 4835 1390 4835 { lab=Vout}
N 1295 4880 1430 4880 { lab=Vg}
N 2145 4775 2280 4775 { lab=VLX}
N 2280 4775 2430 4775 { lab=VLX}
N 2430 4775 2590 4775 { lab=VLX}
N 2590 4775 2750 4775 { lab=VLX}
N 2145 4835 2280 4835 { lab=Vout}
N 2280 4835 2430 4835 { lab=Vout}
N 2430 4835 2590 4835 { lab=Vout}
N 2590 4835 2750 4835 { lab=Vout}
N 2185 4805 2185 4880 { lab=Vg}
N 2185 4880 2320 4880 { lab=Vg}
N 2320 4805 2320 4880 { lab=Vg}
N 2320 4880 2475 4880 { lab=Vg}
N 2790 4805 2790 4880 { lab=Vg}
N 2475 4880 2790 4880 { lab=Vg}
N 2470 4805 2470 4880 { lab=Vg}
N 2630 4805 2630 4880 { lab=Vg}
N 2145 4775 2145 4805 { lab=VLX}
N 2280 4775 2280 4805 { lab=VLX}
N 2430 4775 2430 4805 { lab=VLX}
N 2590 4775 2590 4805 { lab=VLX}
N 2750 4775 2750 4805 { lab=VLX}
N 2885 4775 3020 4775 { lab=VLX}
N 3020 4775 3170 4775 { lab=VLX}
N 3170 4775 3330 4775 { lab=VLX}
N 3330 4775 3490 4775 { lab=VLX}
N 2885 4835 3020 4835 { lab=Vout}
N 3020 4835 3170 4835 { lab=Vout}
N 3170 4835 3330 4835 { lab=Vout}
N 3330 4835 3490 4835 { lab=Vout}
N 2925 4805 2925 4880 { lab=Vg}
N 2925 4880 3060 4880 { lab=Vg}
N 3060 4805 3060 4880 { lab=Vg}
N 3060 4880 3215 4880 { lab=Vg}
N 3530 4805 3530 4880 { lab=Vg}
N 3215 4880 3530 4880 { lab=Vg}
N 3210 4805 3210 4880 { lab=Vg}
N 3370 4805 3370 4880 { lab=Vg}
N 2885 4775 2885 4805 { lab=VLX}
N 3020 4775 3020 4805 { lab=VLX}
N 3170 4775 3170 4805 { lab=VLX}
N 3330 4775 3330 4805 { lab=VLX}
N 3490 4775 3490 4805 { lab=VLX}
N 2750 4775 2885 4775 { lab=VLX}
N 2750 4835 2885 4835 { lab=Vout}
N 2790 4880 2925 4880 { lab=Vg}
N 1995 4775 2145 4775 { lab=VLX}
N 2035 4880 2185 4880 { lab=Vg}
N 1995 4835 2145 4835 { lab=Vout}
N 650 4940 785 4940 { lab=VLX}
N 785 4940 935 4940 { lab=VLX}
N 935 4940 1095 4940 { lab=VLX}
N 1095 4940 1255 4940 { lab=VLX}
N 650 5000 785 5000 { lab=Vout}
N 785 5000 935 5000 { lab=Vout}
N 935 5000 1095 5000 { lab=Vout}
N 1095 5000 1255 5000 { lab=Vout}
N 690 4970 690 5045 { lab=Vg}
N 690 5045 825 5045 { lab=Vg}
N 825 4970 825 5045 { lab=Vg}
N 825 5045 980 5045 { lab=Vg}
N 1295 4970 1295 5045 { lab=Vg}
N 980 5045 1295 5045 { lab=Vg}
N 975 4970 975 5045 { lab=Vg}
N 1135 4970 1135 5045 { lab=Vg}
N 650 4940 650 4970 { lab=VLX}
N 785 4940 785 4970 { lab=VLX}
N 935 4940 935 4970 { lab=VLX}
N 1095 4940 1095 4970 { lab=VLX}
N 1255 4940 1255 4970 { lab=VLX}
N 1390 4940 1525 4940 { lab=VLX}
N 1525 4940 1675 4940 { lab=VLX}
N 1675 4940 1835 4940 { lab=VLX}
N 1835 4940 1995 4940 { lab=VLX}
N 1390 5000 1525 5000 { lab=Vout}
N 1525 5000 1675 5000 { lab=Vout}
N 1675 5000 1835 5000 { lab=Vout}
N 1835 5000 1995 5000 { lab=Vout}
N 1430 4970 1430 5045 { lab=Vg}
N 1430 5045 1565 5045 { lab=Vg}
N 1565 4970 1565 5045 { lab=Vg}
N 1565 5045 1720 5045 { lab=Vg}
N 2035 4970 2035 5045 { lab=Vg}
N 1720 5045 2035 5045 { lab=Vg}
N 1715 4970 1715 5045 { lab=Vg}
N 1875 4970 1875 5045 { lab=Vg}
N 1390 4940 1390 4970 { lab=VLX}
N 1525 4940 1525 4970 { lab=VLX}
N 1675 4940 1675 4970 { lab=VLX}
N 1835 4940 1835 4970 { lab=VLX}
N 1995 4940 1995 4970 { lab=VLX}
N 1255 4940 1390 4940 { lab=VLX}
N 1255 5000 1390 5000 { lab=Vout}
N 1295 5045 1430 5045 { lab=Vg}
N 2145 4940 2280 4940 { lab=VLX}
N 2280 4940 2430 4940 { lab=VLX}
N 2430 4940 2590 4940 { lab=VLX}
N 2590 4940 2750 4940 { lab=VLX}
N 2145 5000 2280 5000 { lab=Vout}
N 2280 5000 2430 5000 { lab=Vout}
N 2430 5000 2590 5000 { lab=Vout}
N 2590 5000 2750 5000 { lab=Vout}
N 2185 4970 2185 5045 { lab=Vg}
N 2185 5045 2320 5045 { lab=Vg}
N 2320 4970 2320 5045 { lab=Vg}
N 2320 5045 2475 5045 { lab=Vg}
N 2790 4970 2790 5045 { lab=Vg}
N 2475 5045 2790 5045 { lab=Vg}
N 2470 4970 2470 5045 { lab=Vg}
N 2630 4970 2630 5045 { lab=Vg}
N 2145 4940 2145 4970 { lab=VLX}
N 2280 4940 2280 4970 { lab=VLX}
N 2430 4940 2430 4970 { lab=VLX}
N 2590 4940 2590 4970 { lab=VLX}
N 2750 4940 2750 4970 { lab=VLX}
N 2885 4940 3020 4940 { lab=VLX}
N 3020 4940 3170 4940 { lab=VLX}
N 3170 4940 3330 4940 { lab=VLX}
N 3330 4940 3490 4940 { lab=VLX}
N 2885 5000 3020 5000 { lab=Vout}
N 3020 5000 3170 5000 { lab=Vout}
N 3170 5000 3330 5000 { lab=Vout}
N 3330 5000 3490 5000 { lab=Vout}
N 2925 4970 2925 5045 { lab=Vg}
N 2925 5045 3060 5045 { lab=Vg}
N 3060 4970 3060 5045 { lab=Vg}
N 3060 5045 3215 5045 { lab=Vg}
N 3530 4970 3530 5045 { lab=Vg}
N 3215 5045 3530 5045 { lab=Vg}
N 3210 4970 3210 5045 { lab=Vg}
N 3370 4970 3370 5045 { lab=Vg}
N 2885 4940 2885 4970 { lab=VLX}
N 3020 4940 3020 4970 { lab=VLX}
N 3170 4940 3170 4970 { lab=VLX}
N 3330 4940 3330 4970 { lab=VLX}
N 3490 4940 3490 4970 { lab=VLX}
N 2750 4940 2885 4940 { lab=VLX}
N 2750 5000 2885 5000 { lab=Vout}
N 2790 5045 2925 5045 { lab=Vg}
N 1995 4940 2145 4940 { lab=VLX}
N 2035 5045 2185 5045 { lab=Vg}
N 1995 5000 2145 5000 { lab=Vout}
N 3530 4880 3530 4970 { lab=Vg}
N 405 4775 650 4775 { lab=VLX}
N 400 4940 650 4940 { lab=VLX}
N 400 4775 400 4940 { lab=VLX}
N 400 4775 405 4775 { lab=VLX}
N 520 4835 650 4835 { lab=Vout}
N 520 4835 520 5045 { lab=Vout}
N 650 5125 785 5125 { lab=VLX}
N 785 5125 935 5125 { lab=VLX}
N 935 5125 1095 5125 { lab=VLX}
N 1095 5125 1255 5125 { lab=VLX}
N 650 5185 785 5185 { lab=Vout}
N 785 5185 935 5185 { lab=Vout}
N 935 5185 1095 5185 { lab=Vout}
N 1095 5185 1255 5185 { lab=Vout}
N 690 5155 690 5230 { lab=Vg}
N 690 5230 825 5230 { lab=Vg}
N 825 5155 825 5230 { lab=Vg}
N 825 5230 980 5230 { lab=Vg}
N 1295 5155 1295 5230 { lab=Vg}
N 980 5230 1295 5230 { lab=Vg}
N 975 5155 975 5230 { lab=Vg}
N 1135 5155 1135 5230 { lab=Vg}
N 650 5125 650 5155 { lab=VLX}
N 785 5125 785 5155 { lab=VLX}
N 935 5125 935 5155 { lab=VLX}
N 1095 5125 1095 5155 { lab=VLX}
N 1255 5125 1255 5155 { lab=VLX}
N 1390 5125 1525 5125 { lab=VLX}
N 1525 5125 1675 5125 { lab=VLX}
N 1675 5125 1835 5125 { lab=VLX}
N 1835 5125 1995 5125 { lab=VLX}
N 1390 5185 1525 5185 { lab=Vout}
N 1525 5185 1675 5185 { lab=Vout}
N 1675 5185 1835 5185 { lab=Vout}
N 1835 5185 1995 5185 { lab=Vout}
N 1430 5155 1430 5230 { lab=Vg}
N 1430 5230 1565 5230 { lab=Vg}
N 1565 5155 1565 5230 { lab=Vg}
N 1565 5230 1720 5230 { lab=Vg}
N 2035 5155 2035 5230 { lab=Vg}
N 1720 5230 2035 5230 { lab=Vg}
N 1715 5155 1715 5230 { lab=Vg}
N 1875 5155 1875 5230 { lab=Vg}
N 1390 5125 1390 5155 { lab=VLX}
N 1525 5125 1525 5155 { lab=VLX}
N 1675 5125 1675 5155 { lab=VLX}
N 1835 5125 1835 5155 { lab=VLX}
N 1995 5125 1995 5155 { lab=VLX}
N 1255 5125 1390 5125 { lab=VLX}
N 1255 5185 1390 5185 { lab=Vout}
N 1295 5230 1430 5230 { lab=Vg}
N 2145 5125 2280 5125 { lab=VLX}
N 2280 5125 2430 5125 { lab=VLX}
N 2430 5125 2590 5125 { lab=VLX}
N 2590 5125 2750 5125 { lab=VLX}
N 2145 5185 2280 5185 { lab=Vout}
N 2280 5185 2430 5185 { lab=Vout}
N 2430 5185 2590 5185 { lab=Vout}
N 2590 5185 2750 5185 { lab=Vout}
N 2185 5155 2185 5230 { lab=Vg}
N 2185 5230 2320 5230 { lab=Vg}
N 2320 5155 2320 5230 { lab=Vg}
N 2320 5230 2475 5230 { lab=Vg}
N 2790 5155 2790 5230 { lab=Vg}
N 2475 5230 2790 5230 { lab=Vg}
N 2470 5155 2470 5230 { lab=Vg}
N 2630 5155 2630 5230 { lab=Vg}
N 2145 5125 2145 5155 { lab=VLX}
N 2280 5125 2280 5155 { lab=VLX}
N 2430 5125 2430 5155 { lab=VLX}
N 2590 5125 2590 5155 { lab=VLX}
N 2750 5125 2750 5155 { lab=VLX}
N 2885 5125 3020 5125 { lab=VLX}
N 3020 5125 3170 5125 { lab=VLX}
N 3170 5125 3330 5125 { lab=VLX}
N 3330 5125 3490 5125 { lab=VLX}
N 2885 5185 3020 5185 { lab=Vout}
N 3020 5185 3170 5185 { lab=Vout}
N 3170 5185 3330 5185 { lab=Vout}
N 3330 5185 3490 5185 { lab=Vout}
N 2925 5155 2925 5230 { lab=Vg}
N 2925 5230 3060 5230 { lab=Vg}
N 3060 5155 3060 5230 { lab=Vg}
N 3060 5230 3215 5230 { lab=Vg}
N 3530 5155 3530 5230 { lab=Vg}
N 3215 5230 3530 5230 { lab=Vg}
N 3210 5155 3210 5230 { lab=Vg}
N 3370 5155 3370 5230 { lab=Vg}
N 2885 5125 2885 5155 { lab=VLX}
N 3020 5125 3020 5155 { lab=VLX}
N 3170 5125 3170 5155 { lab=VLX}
N 3330 5125 3330 5155 { lab=VLX}
N 3490 5125 3490 5155 { lab=VLX}
N 2750 5125 2885 5125 { lab=VLX}
N 2750 5185 2885 5185 { lab=Vout}
N 2790 5230 2925 5230 { lab=Vg}
N 1995 5125 2145 5125 { lab=VLX}
N 2035 5230 2185 5230 { lab=Vg}
N 1995 5185 2145 5185 { lab=Vout}
N 650 5290 785 5290 { lab=VLX}
N 785 5290 935 5290 { lab=VLX}
N 935 5290 1095 5290 { lab=VLX}
N 1095 5290 1255 5290 { lab=VLX}
N 650 5350 785 5350 { lab=Vout}
N 785 5350 935 5350 { lab=Vout}
N 935 5350 1095 5350 { lab=Vout}
N 1095 5350 1255 5350 { lab=Vout}
N 690 5320 690 5395 { lab=Vg}
N 690 5395 825 5395 { lab=Vg}
N 825 5320 825 5395 { lab=Vg}
N 825 5395 980 5395 { lab=Vg}
N 1295 5320 1295 5395 { lab=Vg}
N 980 5395 1295 5395 { lab=Vg}
N 975 5320 975 5395 { lab=Vg}
N 1135 5320 1135 5395 { lab=Vg}
N 650 5290 650 5320 { lab=VLX}
N 785 5290 785 5320 { lab=VLX}
N 935 5290 935 5320 { lab=VLX}
N 1095 5290 1095 5320 { lab=VLX}
N 1255 5290 1255 5320 { lab=VLX}
N 1390 5290 1525 5290 { lab=VLX}
N 1525 5290 1675 5290 { lab=VLX}
N 1675 5290 1835 5290 { lab=VLX}
N 1835 5290 1995 5290 { lab=VLX}
N 1390 5350 1525 5350 { lab=Vout}
N 1525 5350 1675 5350 { lab=Vout}
N 1675 5350 1835 5350 { lab=Vout}
N 1835 5350 1995 5350 { lab=Vout}
N 1430 5320 1430 5395 { lab=Vg}
N 1430 5395 1565 5395 { lab=Vg}
N 1565 5320 1565 5395 { lab=Vg}
N 1565 5395 1720 5395 { lab=Vg}
N 2035 5320 2035 5395 { lab=Vg}
N 1720 5395 2035 5395 { lab=Vg}
N 1715 5320 1715 5395 { lab=Vg}
N 1875 5320 1875 5395 { lab=Vg}
N 1390 5290 1390 5320 { lab=VLX}
N 1525 5290 1525 5320 { lab=VLX}
N 1675 5290 1675 5320 { lab=VLX}
N 1835 5290 1835 5320 { lab=VLX}
N 1995 5290 1995 5320 { lab=VLX}
N 1255 5290 1390 5290 { lab=VLX}
N 1255 5350 1390 5350 { lab=Vout}
N 1295 5395 1430 5395 { lab=Vg}
N 2145 5290 2280 5290 { lab=VLX}
N 2280 5290 2430 5290 { lab=VLX}
N 2430 5290 2590 5290 { lab=VLX}
N 2590 5290 2750 5290 { lab=VLX}
N 2145 5350 2280 5350 { lab=Vout}
N 2280 5350 2430 5350 { lab=Vout}
N 2430 5350 2590 5350 { lab=Vout}
N 2590 5350 2750 5350 { lab=Vout}
N 2185 5320 2185 5395 { lab=Vg}
N 2185 5395 2320 5395 { lab=Vg}
N 2320 5320 2320 5395 { lab=Vg}
N 2320 5395 2475 5395 { lab=Vg}
N 2790 5320 2790 5395 { lab=Vg}
N 2475 5395 2790 5395 { lab=Vg}
N 2470 5320 2470 5395 { lab=Vg}
N 2630 5320 2630 5395 { lab=Vg}
N 2145 5290 2145 5320 { lab=VLX}
N 2280 5290 2280 5320 { lab=VLX}
N 2430 5290 2430 5320 { lab=VLX}
N 2590 5290 2590 5320 { lab=VLX}
N 2750 5290 2750 5320 { lab=VLX}
N 2885 5290 3020 5290 { lab=VLX}
N 3020 5290 3170 5290 { lab=VLX}
N 3170 5290 3330 5290 { lab=VLX}
N 3330 5290 3490 5290 { lab=VLX}
N 2885 5350 3020 5350 { lab=Vout}
N 3020 5350 3170 5350 { lab=Vout}
N 3170 5350 3330 5350 { lab=Vout}
N 3330 5350 3490 5350 { lab=Vout}
N 2925 5320 2925 5395 { lab=Vg}
N 2925 5395 3060 5395 { lab=Vg}
N 3060 5320 3060 5395 { lab=Vg}
N 3060 5395 3215 5395 { lab=Vg}
N 3530 5320 3530 5395 { lab=Vg}
N 3215 5395 3530 5395 { lab=Vg}
N 3210 5320 3210 5395 { lab=Vg}
N 3370 5320 3370 5395 { lab=Vg}
N 2885 5290 2885 5320 { lab=VLX}
N 3020 5290 3020 5320 { lab=VLX}
N 3170 5290 3170 5320 { lab=VLX}
N 3330 5290 3330 5320 { lab=VLX}
N 3490 5290 3490 5320 { lab=VLX}
N 2750 5290 2885 5290 { lab=VLX}
N 2750 5350 2885 5350 { lab=Vout}
N 2790 5395 2925 5395 { lab=Vg}
N 1995 5290 2145 5290 { lab=VLX}
N 2035 5395 2185 5395 { lab=Vg}
N 1995 5350 2145 5350 { lab=Vout}
N 3530 5230 3530 5320 { lab=Vg}
N 405 5125 650 5125 { lab=VLX}
N 400 5290 650 5290 { lab=VLX}
N 400 5125 400 5290 { lab=VLX}
N 400 5125 405 5125 { lab=VLX}
N 520 5185 650 5185 { lab=Vout}
N 520 5185 520 5395 { lab=Vout}
N 400 4940 400 5130 { lab=VLX}
N 520 5040 520 5190 { lab=Vout}
N 3530 5040 3530 5160 { lab=Vg}
N 650 5445 785 5445 { lab=VLX}
N 785 5445 935 5445 { lab=VLX}
N 935 5445 1095 5445 { lab=VLX}
N 1095 5445 1255 5445 { lab=VLX}
N 650 5505 785 5505 { lab=Vout}
N 785 5505 935 5505 { lab=Vout}
N 935 5505 1095 5505 { lab=Vout}
N 1095 5505 1255 5505 { lab=Vout}
N 690 5475 690 5550 { lab=Vg}
N 690 5550 825 5550 { lab=Vg}
N 825 5475 825 5550 { lab=Vg}
N 825 5550 980 5550 { lab=Vg}
N 1295 5475 1295 5550 { lab=Vg}
N 980 5550 1295 5550 { lab=Vg}
N 975 5475 975 5550 { lab=Vg}
N 1135 5475 1135 5550 { lab=Vg}
N 650 5445 650 5475 { lab=VLX}
N 785 5445 785 5475 { lab=VLX}
N 935 5445 935 5475 { lab=VLX}
N 1095 5445 1095 5475 { lab=VLX}
N 1255 5445 1255 5475 { lab=VLX}
N 1390 5445 1525 5445 { lab=VLX}
N 1525 5445 1675 5445 { lab=VLX}
N 1675 5445 1835 5445 { lab=VLX}
N 1835 5445 1995 5445 { lab=VLX}
N 1390 5505 1525 5505 { lab=Vout}
N 1525 5505 1675 5505 { lab=Vout}
N 1675 5505 1835 5505 { lab=Vout}
N 1835 5505 1995 5505 { lab=Vout}
N 1430 5475 1430 5550 { lab=Vg}
N 1430 5550 1565 5550 { lab=Vg}
N 1565 5475 1565 5550 { lab=Vg}
N 1565 5550 1720 5550 { lab=Vg}
N 2035 5475 2035 5550 { lab=Vg}
N 1720 5550 2035 5550 { lab=Vg}
N 1715 5475 1715 5550 { lab=Vg}
N 1875 5475 1875 5550 { lab=Vg}
N 1390 5445 1390 5475 { lab=VLX}
N 1525 5445 1525 5475 { lab=VLX}
N 1675 5445 1675 5475 { lab=VLX}
N 1835 5445 1835 5475 { lab=VLX}
N 1995 5445 1995 5475 { lab=VLX}
N 1255 5445 1390 5445 { lab=VLX}
N 1255 5505 1390 5505 { lab=Vout}
N 1295 5550 1430 5550 { lab=Vg}
N 2145 5445 2280 5445 { lab=VLX}
N 2280 5445 2430 5445 { lab=VLX}
N 2430 5445 2590 5445 { lab=VLX}
N 2590 5445 2750 5445 { lab=VLX}
N 2145 5505 2280 5505 { lab=Vout}
N 2280 5505 2430 5505 { lab=Vout}
N 2430 5505 2590 5505 { lab=Vout}
N 2590 5505 2750 5505 { lab=Vout}
N 2185 5475 2185 5550 { lab=Vg}
N 2185 5550 2320 5550 { lab=Vg}
N 2320 5475 2320 5550 { lab=Vg}
N 2320 5550 2475 5550 { lab=Vg}
N 2790 5475 2790 5550 { lab=Vg}
N 2475 5550 2790 5550 { lab=Vg}
N 2470 5475 2470 5550 { lab=Vg}
N 2630 5475 2630 5550 { lab=Vg}
N 2145 5445 2145 5475 { lab=VLX}
N 2280 5445 2280 5475 { lab=VLX}
N 2430 5445 2430 5475 { lab=VLX}
N 2590 5445 2590 5475 { lab=VLX}
N 2750 5445 2750 5475 { lab=VLX}
N 2885 5445 3020 5445 { lab=VLX}
N 3020 5445 3170 5445 { lab=VLX}
N 3170 5445 3330 5445 { lab=VLX}
N 3330 5445 3490 5445 { lab=VLX}
N 2885 5505 3020 5505 { lab=Vout}
N 3020 5505 3170 5505 { lab=Vout}
N 3170 5505 3330 5505 { lab=Vout}
N 3330 5505 3490 5505 { lab=Vout}
N 2925 5475 2925 5550 { lab=Vg}
N 2925 5550 3060 5550 { lab=Vg}
N 3060 5475 3060 5550 { lab=Vg}
N 3060 5550 3215 5550 { lab=Vg}
N 3530 5475 3530 5550 { lab=Vg}
N 3215 5550 3530 5550 { lab=Vg}
N 3210 5475 3210 5550 { lab=Vg}
N 3370 5475 3370 5550 { lab=Vg}
N 2885 5445 2885 5475 { lab=VLX}
N 3020 5445 3020 5475 { lab=VLX}
N 3170 5445 3170 5475 { lab=VLX}
N 3330 5445 3330 5475 { lab=VLX}
N 3490 5445 3490 5475 { lab=VLX}
N 2750 5445 2885 5445 { lab=VLX}
N 2750 5505 2885 5505 { lab=Vout}
N 2790 5550 2925 5550 { lab=Vg}
N 1995 5445 2145 5445 { lab=VLX}
N 2035 5550 2185 5550 { lab=Vg}
N 1995 5505 2145 5505 { lab=Vout}
N 650 5610 785 5610 { lab=VLX}
N 785 5610 935 5610 { lab=VLX}
N 935 5610 1095 5610 { lab=VLX}
N 1095 5610 1255 5610 { lab=VLX}
N 650 5670 785 5670 { lab=Vout}
N 785 5670 935 5670 { lab=Vout}
N 935 5670 1095 5670 { lab=Vout}
N 1095 5670 1255 5670 { lab=Vout}
N 690 5640 690 5715 { lab=Vg}
N 690 5715 825 5715 { lab=Vg}
N 825 5640 825 5715 { lab=Vg}
N 825 5715 980 5715 { lab=Vg}
N 1295 5640 1295 5715 { lab=Vg}
N 980 5715 1295 5715 { lab=Vg}
N 975 5640 975 5715 { lab=Vg}
N 1135 5640 1135 5715 { lab=Vg}
N 650 5610 650 5640 { lab=VLX}
N 785 5610 785 5640 { lab=VLX}
N 935 5610 935 5640 { lab=VLX}
N 1095 5610 1095 5640 { lab=VLX}
N 1255 5610 1255 5640 { lab=VLX}
N 1390 5610 1525 5610 { lab=VLX}
N 1525 5610 1675 5610 { lab=VLX}
N 1675 5610 1835 5610 { lab=VLX}
N 1835 5610 1995 5610 { lab=VLX}
N 1390 5670 1525 5670 { lab=Vout}
N 1525 5670 1675 5670 { lab=Vout}
N 1675 5670 1835 5670 { lab=Vout}
N 1835 5670 1995 5670 { lab=Vout}
N 1430 5640 1430 5715 { lab=Vg}
N 1430 5715 1565 5715 { lab=Vg}
N 1565 5640 1565 5715 { lab=Vg}
N 1565 5715 1720 5715 { lab=Vg}
N 2035 5640 2035 5715 { lab=Vg}
N 1720 5715 2035 5715 { lab=Vg}
N 1715 5640 1715 5715 { lab=Vg}
N 1875 5640 1875 5715 { lab=Vg}
N 1390 5610 1390 5640 { lab=VLX}
N 1525 5610 1525 5640 { lab=VLX}
N 1675 5610 1675 5640 { lab=VLX}
N 1835 5610 1835 5640 { lab=VLX}
N 1995 5610 1995 5640 { lab=VLX}
N 1255 5610 1390 5610 { lab=VLX}
N 1255 5670 1390 5670 { lab=Vout}
N 1295 5715 1430 5715 { lab=Vg}
N 2145 5610 2280 5610 { lab=VLX}
N 2280 5610 2430 5610 { lab=VLX}
N 2430 5610 2590 5610 { lab=VLX}
N 2590 5610 2750 5610 { lab=VLX}
N 2145 5670 2280 5670 { lab=Vout}
N 2280 5670 2430 5670 { lab=Vout}
N 2430 5670 2590 5670 { lab=Vout}
N 2590 5670 2750 5670 { lab=Vout}
N 2185 5640 2185 5715 { lab=Vg}
N 2185 5715 2320 5715 { lab=Vg}
N 2320 5640 2320 5715 { lab=Vg}
N 2320 5715 2475 5715 { lab=Vg}
N 2790 5640 2790 5715 { lab=Vg}
N 2475 5715 2790 5715 { lab=Vg}
N 2470 5640 2470 5715 { lab=Vg}
N 2630 5640 2630 5715 { lab=Vg}
N 2145 5610 2145 5640 { lab=VLX}
N 2280 5610 2280 5640 { lab=VLX}
N 2430 5610 2430 5640 { lab=VLX}
N 2590 5610 2590 5640 { lab=VLX}
N 2750 5610 2750 5640 { lab=VLX}
N 2885 5610 3020 5610 { lab=VLX}
N 3020 5610 3170 5610 { lab=VLX}
N 3170 5610 3330 5610 { lab=VLX}
N 3330 5610 3490 5610 { lab=VLX}
N 2885 5670 3020 5670 { lab=Vout}
N 3020 5670 3170 5670 { lab=Vout}
N 3170 5670 3330 5670 { lab=Vout}
N 3330 5670 3490 5670 { lab=Vout}
N 2925 5640 2925 5715 { lab=Vg}
N 2925 5715 3060 5715 { lab=Vg}
N 3060 5640 3060 5715 { lab=Vg}
N 3060 5715 3215 5715 { lab=Vg}
N 3530 5640 3530 5715 { lab=Vg}
N 3215 5715 3530 5715 { lab=Vg}
N 3210 5640 3210 5715 { lab=Vg}
N 3370 5640 3370 5715 { lab=Vg}
N 2885 5610 2885 5640 { lab=VLX}
N 3020 5610 3020 5640 { lab=VLX}
N 3170 5610 3170 5640 { lab=VLX}
N 3330 5610 3330 5640 { lab=VLX}
N 3490 5610 3490 5640 { lab=VLX}
N 2750 5610 2885 5610 { lab=VLX}
N 2750 5670 2885 5670 { lab=Vout}
N 2790 5715 2925 5715 { lab=Vg}
N 1995 5610 2145 5610 { lab=VLX}
N 2035 5715 2185 5715 { lab=Vg}
N 1995 5670 2145 5670 { lab=Vout}
N 3530 5550 3530 5640 { lab=Vg}
N 405 5445 650 5445 { lab=VLX}
N 400 5610 650 5610 { lab=VLX}
N 400 5445 400 5610 { lab=VLX}
N 400 5445 405 5445 { lab=VLX}
N 520 5505 650 5505 { lab=Vout}
N 520 5505 520 5715 { lab=Vout}
N 650 5795 785 5795 { lab=VLX}
N 785 5795 935 5795 { lab=VLX}
N 935 5795 1095 5795 { lab=VLX}
N 1095 5795 1255 5795 { lab=VLX}
N 650 5855 785 5855 { lab=Vout}
N 785 5855 935 5855 { lab=Vout}
N 935 5855 1095 5855 { lab=Vout}
N 1095 5855 1255 5855 { lab=Vout}
N 690 5825 690 5900 { lab=Vg}
N 690 5900 825 5900 { lab=Vg}
N 825 5825 825 5900 { lab=Vg}
N 825 5900 980 5900 { lab=Vg}
N 1295 5825 1295 5900 { lab=Vg}
N 980 5900 1295 5900 { lab=Vg}
N 975 5825 975 5900 { lab=Vg}
N 1135 5825 1135 5900 { lab=Vg}
N 650 5795 650 5825 { lab=VLX}
N 785 5795 785 5825 { lab=VLX}
N 935 5795 935 5825 { lab=VLX}
N 1095 5795 1095 5825 { lab=VLX}
N 1255 5795 1255 5825 { lab=VLX}
N 1390 5795 1525 5795 { lab=VLX}
N 1525 5795 1675 5795 { lab=VLX}
N 1675 5795 1835 5795 { lab=VLX}
N 1835 5795 1995 5795 { lab=VLX}
N 1390 5855 1525 5855 { lab=Vout}
N 1525 5855 1675 5855 { lab=Vout}
N 1675 5855 1835 5855 { lab=Vout}
N 1835 5855 1995 5855 { lab=Vout}
N 1430 5825 1430 5900 { lab=Vg}
N 1430 5900 1565 5900 { lab=Vg}
N 1565 5825 1565 5900 { lab=Vg}
N 1565 5900 1720 5900 { lab=Vg}
N 2035 5825 2035 5900 { lab=Vg}
N 1720 5900 2035 5900 { lab=Vg}
N 1715 5825 1715 5900 { lab=Vg}
N 1875 5825 1875 5900 { lab=Vg}
N 1390 5795 1390 5825 { lab=VLX}
N 1525 5795 1525 5825 { lab=VLX}
N 1675 5795 1675 5825 { lab=VLX}
N 1835 5795 1835 5825 { lab=VLX}
N 1995 5795 1995 5825 { lab=VLX}
N 1255 5795 1390 5795 { lab=VLX}
N 1255 5855 1390 5855 { lab=Vout}
N 1295 5900 1430 5900 { lab=Vg}
N 2145 5795 2280 5795 { lab=VLX}
N 2280 5795 2430 5795 { lab=VLX}
N 2430 5795 2590 5795 { lab=VLX}
N 2590 5795 2750 5795 { lab=VLX}
N 2145 5855 2280 5855 { lab=Vout}
N 2280 5855 2430 5855 { lab=Vout}
N 2430 5855 2590 5855 { lab=Vout}
N 2590 5855 2750 5855 { lab=Vout}
N 2185 5825 2185 5900 { lab=Vg}
N 2185 5900 2320 5900 { lab=Vg}
N 2320 5825 2320 5900 { lab=Vg}
N 2320 5900 2475 5900 { lab=Vg}
N 2790 5825 2790 5900 { lab=Vg}
N 2475 5900 2790 5900 { lab=Vg}
N 2470 5825 2470 5900 { lab=Vg}
N 2630 5825 2630 5900 { lab=Vg}
N 2145 5795 2145 5825 { lab=VLX}
N 2280 5795 2280 5825 { lab=VLX}
N 2430 5795 2430 5825 { lab=VLX}
N 2590 5795 2590 5825 { lab=VLX}
N 2750 5795 2750 5825 { lab=VLX}
N 2885 5795 3020 5795 { lab=VLX}
N 3020 5795 3170 5795 { lab=VLX}
N 3170 5795 3330 5795 { lab=VLX}
N 3330 5795 3490 5795 { lab=VLX}
N 2885 5855 3020 5855 { lab=Vout}
N 3020 5855 3170 5855 { lab=Vout}
N 3170 5855 3330 5855 { lab=Vout}
N 3330 5855 3490 5855 { lab=Vout}
N 2925 5825 2925 5900 { lab=Vg}
N 2925 5900 3060 5900 { lab=Vg}
N 3060 5825 3060 5900 { lab=Vg}
N 3060 5900 3215 5900 { lab=Vg}
N 3530 5825 3530 5900 { lab=Vg}
N 3215 5900 3530 5900 { lab=Vg}
N 3210 5825 3210 5900 { lab=Vg}
N 3370 5825 3370 5900 { lab=Vg}
N 2885 5795 2885 5825 { lab=VLX}
N 3020 5795 3020 5825 { lab=VLX}
N 3170 5795 3170 5825 { lab=VLX}
N 3330 5795 3330 5825 { lab=VLX}
N 3490 5795 3490 5825 { lab=VLX}
N 2750 5795 2885 5795 { lab=VLX}
N 2750 5855 2885 5855 { lab=Vout}
N 2790 5900 2925 5900 { lab=Vg}
N 1995 5795 2145 5795 { lab=VLX}
N 2035 5900 2185 5900 { lab=Vg}
N 1995 5855 2145 5855 { lab=Vout}
N 650 5960 785 5960 { lab=VLX}
N 785 5960 935 5960 { lab=VLX}
N 935 5960 1095 5960 { lab=VLX}
N 1095 5960 1255 5960 { lab=VLX}
N 650 6020 785 6020 { lab=Vout}
N 785 6020 935 6020 { lab=Vout}
N 935 6020 1095 6020 { lab=Vout}
N 1095 6020 1255 6020 { lab=Vout}
N 690 5990 690 6065 { lab=Vg}
N 690 6065 825 6065 { lab=Vg}
N 825 5990 825 6065 { lab=Vg}
N 825 6065 980 6065 { lab=Vg}
N 1295 5990 1295 6065 { lab=Vg}
N 980 6065 1295 6065 { lab=Vg}
N 975 5990 975 6065 { lab=Vg}
N 1135 5990 1135 6065 { lab=Vg}
N 650 5960 650 5990 { lab=VLX}
N 785 5960 785 5990 { lab=VLX}
N 935 5960 935 5990 { lab=VLX}
N 1095 5960 1095 5990 { lab=VLX}
N 1255 5960 1255 5990 { lab=VLX}
N 1390 5960 1525 5960 { lab=VLX}
N 1525 5960 1675 5960 { lab=VLX}
N 1675 5960 1835 5960 { lab=VLX}
N 1835 5960 1995 5960 { lab=VLX}
N 1390 6020 1525 6020 { lab=Vout}
N 1525 6020 1675 6020 { lab=Vout}
N 1675 6020 1835 6020 { lab=Vout}
N 1835 6020 1995 6020 { lab=Vout}
N 1430 5990 1430 6065 { lab=Vg}
N 1430 6065 1565 6065 { lab=Vg}
N 1565 5990 1565 6065 { lab=Vg}
N 1565 6065 1720 6065 { lab=Vg}
N 2035 5990 2035 6065 { lab=Vg}
N 1720 6065 2035 6065 { lab=Vg}
N 1715 5990 1715 6065 { lab=Vg}
N 1875 5990 1875 6065 { lab=Vg}
N 1390 5960 1390 5990 { lab=VLX}
N 1525 5960 1525 5990 { lab=VLX}
N 1675 5960 1675 5990 { lab=VLX}
N 1835 5960 1835 5990 { lab=VLX}
N 1995 5960 1995 5990 { lab=VLX}
N 1255 5960 1390 5960 { lab=VLX}
N 1255 6020 1390 6020 { lab=Vout}
N 1295 6065 1430 6065 { lab=Vg}
N 2145 5960 2280 5960 { lab=VLX}
N 2280 5960 2430 5960 { lab=VLX}
N 2430 5960 2590 5960 { lab=VLX}
N 2590 5960 2750 5960 { lab=VLX}
N 2145 6020 2280 6020 { lab=Vout}
N 2280 6020 2430 6020 { lab=Vout}
N 2430 6020 2590 6020 { lab=Vout}
N 2590 6020 2750 6020 { lab=Vout}
N 2185 5990 2185 6065 { lab=Vg}
N 2185 6065 2320 6065 { lab=Vg}
N 2320 5990 2320 6065 { lab=Vg}
N 2320 6065 2475 6065 { lab=Vg}
N 2790 5990 2790 6065 { lab=Vg}
N 2475 6065 2790 6065 { lab=Vg}
N 2470 5990 2470 6065 { lab=Vg}
N 2630 5990 2630 6065 { lab=Vg}
N 2145 5960 2145 5990 { lab=VLX}
N 2280 5960 2280 5990 { lab=VLX}
N 2430 5960 2430 5990 { lab=VLX}
N 2590 5960 2590 5990 { lab=VLX}
N 2750 5960 2750 5990 { lab=VLX}
N 2885 5960 3020 5960 { lab=VLX}
N 3020 5960 3170 5960 { lab=VLX}
N 3170 5960 3330 5960 { lab=VLX}
N 3330 5960 3490 5960 { lab=VLX}
N 2885 6020 3020 6020 { lab=Vout}
N 3020 6020 3170 6020 { lab=Vout}
N 3170 6020 3330 6020 { lab=Vout}
N 3330 6020 3490 6020 { lab=Vout}
N 2925 5990 2925 6065 { lab=Vg}
N 2925 6065 3060 6065 { lab=Vg}
N 3060 5990 3060 6065 { lab=Vg}
N 3060 6065 3215 6065 { lab=Vg}
N 3530 5990 3530 6065 { lab=Vg}
N 3215 6065 3530 6065 { lab=Vg}
N 3210 5990 3210 6065 { lab=Vg}
N 3370 5990 3370 6065 { lab=Vg}
N 2885 5960 2885 5990 { lab=VLX}
N 3020 5960 3020 5990 { lab=VLX}
N 3170 5960 3170 5990 { lab=VLX}
N 3330 5960 3330 5990 { lab=VLX}
N 3490 5960 3490 5990 { lab=VLX}
N 2750 5960 2885 5960 { lab=VLX}
N 2750 6020 2885 6020 { lab=Vout}
N 2790 6065 2925 6065 { lab=Vg}
N 1995 5960 2145 5960 { lab=VLX}
N 2035 6065 2185 6065 { lab=Vg}
N 1995 6020 2145 6020 { lab=Vout}
N 3530 5900 3530 5990 { lab=Vg}
N 405 5795 650 5795 { lab=VLX}
N 400 5960 650 5960 { lab=VLX}
N 400 5795 400 5960 { lab=VLX}
N 400 5795 405 5795 { lab=VLX}
N 520 5855 650 5855 { lab=Vout}
N 520 5855 520 6065 { lab=Vout}
N 400 5610 400 5800 { lab=VLX}
N 520 5710 520 5860 { lab=Vout}
N 3530 5710 3530 5830 { lab=Vg}
N 400 5290 400 5450 { lab=VLX}
N 520 5390 520 5510 { lab=Vout}
N 3530 5400 3530 5470 { lab=Vg}
N 3530 5390 3530 5400 { lab=Vg}
N 3530 4640 3530 4810 { lab=Vg}
N 520 4640 520 4850 { lab=Vout}
N 400 4540 400 4780 { lab=VLX}
N 650 6215 785 6215 { lab=VLX}
N 785 6215 935 6215 { lab=VLX}
N 935 6215 1095 6215 { lab=VLX}
N 1095 6215 1255 6215 { lab=VLX}
N 650 6275 785 6275 { lab=Vout}
N 785 6275 935 6275 { lab=Vout}
N 935 6275 1095 6275 { lab=Vout}
N 1095 6275 1255 6275 { lab=Vout}
N 690 6245 690 6320 { lab=Vg}
N 690 6320 825 6320 { lab=Vg}
N 825 6245 825 6320 { lab=Vg}
N 825 6320 980 6320 { lab=Vg}
N 1295 6245 1295 6320 { lab=Vg}
N 980 6320 1295 6320 { lab=Vg}
N 975 6245 975 6320 { lab=Vg}
N 1135 6245 1135 6320 { lab=Vg}
N 650 6215 650 6245 { lab=VLX}
N 785 6215 785 6245 { lab=VLX}
N 935 6215 935 6245 { lab=VLX}
N 1095 6215 1095 6245 { lab=VLX}
N 1255 6215 1255 6245 { lab=VLX}
N 1390 6215 1525 6215 { lab=VLX}
N 1525 6215 1675 6215 { lab=VLX}
N 1675 6215 1835 6215 { lab=VLX}
N 1835 6215 1995 6215 { lab=VLX}
N 1390 6275 1525 6275 { lab=Vout}
N 1525 6275 1675 6275 { lab=Vout}
N 1675 6275 1835 6275 { lab=Vout}
N 1835 6275 1995 6275 { lab=Vout}
N 1430 6245 1430 6320 { lab=Vg}
N 1430 6320 1565 6320 { lab=Vg}
N 1565 6245 1565 6320 { lab=Vg}
N 1565 6320 1720 6320 { lab=Vg}
N 2035 6245 2035 6320 { lab=Vg}
N 1720 6320 2035 6320 { lab=Vg}
N 1715 6245 1715 6320 { lab=Vg}
N 1875 6245 1875 6320 { lab=Vg}
N 1390 6215 1390 6245 { lab=VLX}
N 1525 6215 1525 6245 { lab=VLX}
N 1675 6215 1675 6245 { lab=VLX}
N 1835 6215 1835 6245 { lab=VLX}
N 1995 6215 1995 6245 { lab=VLX}
N 1255 6215 1390 6215 { lab=VLX}
N 1255 6275 1390 6275 { lab=Vout}
N 1295 6320 1430 6320 { lab=Vg}
N 2145 6215 2280 6215 { lab=VLX}
N 2280 6215 2430 6215 { lab=VLX}
N 2430 6215 2590 6215 { lab=VLX}
N 2590 6215 2750 6215 { lab=VLX}
N 2145 6275 2280 6275 { lab=Vout}
N 2280 6275 2430 6275 { lab=Vout}
N 2430 6275 2590 6275 { lab=Vout}
N 2590 6275 2750 6275 { lab=Vout}
N 2185 6245 2185 6320 { lab=Vg}
N 2185 6320 2320 6320 { lab=Vg}
N 2320 6245 2320 6320 { lab=Vg}
N 2320 6320 2475 6320 { lab=Vg}
N 2790 6245 2790 6320 { lab=Vg}
N 2475 6320 2790 6320 { lab=Vg}
N 2470 6245 2470 6320 { lab=Vg}
N 2630 6245 2630 6320 { lab=Vg}
N 2145 6215 2145 6245 { lab=VLX}
N 2280 6215 2280 6245 { lab=VLX}
N 2430 6215 2430 6245 { lab=VLX}
N 2590 6215 2590 6245 { lab=VLX}
N 2750 6215 2750 6245 { lab=VLX}
N 2885 6215 3020 6215 { lab=VLX}
N 3020 6215 3170 6215 { lab=VLX}
N 3170 6215 3330 6215 { lab=VLX}
N 3330 6215 3490 6215 { lab=VLX}
N 2885 6275 3020 6275 { lab=Vout}
N 3020 6275 3170 6275 { lab=Vout}
N 3170 6275 3330 6275 { lab=Vout}
N 3330 6275 3490 6275 { lab=Vout}
N 2925 6245 2925 6320 { lab=Vg}
N 2925 6320 3060 6320 { lab=Vg}
N 3060 6245 3060 6320 { lab=Vg}
N 3060 6320 3215 6320 { lab=Vg}
N 3530 6245 3530 6320 { lab=Vg}
N 3215 6320 3530 6320 { lab=Vg}
N 3210 6245 3210 6320 { lab=Vg}
N 3370 6245 3370 6320 { lab=Vg}
N 2885 6215 2885 6245 { lab=VLX}
N 3020 6215 3020 6245 { lab=VLX}
N 3170 6215 3170 6245 { lab=VLX}
N 3330 6215 3330 6245 { lab=VLX}
N 3490 6215 3490 6245 { lab=VLX}
N 2750 6215 2885 6215 { lab=VLX}
N 2750 6275 2885 6275 { lab=Vout}
N 2790 6320 2925 6320 { lab=Vg}
N 1995 6215 2145 6215 { lab=VLX}
N 2035 6320 2185 6320 { lab=Vg}
N 1995 6275 2145 6275 { lab=Vout}
N 650 6380 785 6380 { lab=VLX}
N 785 6380 935 6380 { lab=VLX}
N 935 6380 1095 6380 { lab=VLX}
N 1095 6380 1255 6380 { lab=VLX}
N 650 6440 785 6440 { lab=Vout}
N 785 6440 935 6440 { lab=Vout}
N 935 6440 1095 6440 { lab=Vout}
N 1095 6440 1255 6440 { lab=Vout}
N 690 6410 690 6485 { lab=Vg}
N 690 6485 825 6485 { lab=Vg}
N 825 6410 825 6485 { lab=Vg}
N 825 6485 980 6485 { lab=Vg}
N 1295 6410 1295 6485 { lab=Vg}
N 980 6485 1295 6485 { lab=Vg}
N 975 6410 975 6485 { lab=Vg}
N 1135 6410 1135 6485 { lab=Vg}
N 650 6380 650 6410 { lab=VLX}
N 785 6380 785 6410 { lab=VLX}
N 935 6380 935 6410 { lab=VLX}
N 1095 6380 1095 6410 { lab=VLX}
N 1255 6380 1255 6410 { lab=VLX}
N 1390 6380 1525 6380 { lab=VLX}
N 1525 6380 1675 6380 { lab=VLX}
N 1675 6380 1835 6380 { lab=VLX}
N 1835 6380 1995 6380 { lab=VLX}
N 1390 6440 1525 6440 { lab=Vout}
N 1525 6440 1675 6440 { lab=Vout}
N 1675 6440 1835 6440 { lab=Vout}
N 1835 6440 1995 6440 { lab=Vout}
N 1430 6410 1430 6485 { lab=Vg}
N 1430 6485 1565 6485 { lab=Vg}
N 1565 6410 1565 6485 { lab=Vg}
N 1565 6485 1720 6485 { lab=Vg}
N 2035 6410 2035 6485 { lab=Vg}
N 1720 6485 2035 6485 { lab=Vg}
N 1715 6410 1715 6485 { lab=Vg}
N 1875 6410 1875 6485 { lab=Vg}
N 1390 6380 1390 6410 { lab=VLX}
N 1525 6380 1525 6410 { lab=VLX}
N 1675 6380 1675 6410 { lab=VLX}
N 1835 6380 1835 6410 { lab=VLX}
N 1995 6380 1995 6410 { lab=VLX}
N 1255 6380 1390 6380 { lab=VLX}
N 1255 6440 1390 6440 { lab=Vout}
N 1295 6485 1430 6485 { lab=Vg}
N 2145 6380 2280 6380 { lab=VLX}
N 2280 6380 2430 6380 { lab=VLX}
N 2430 6380 2590 6380 { lab=VLX}
N 2590 6380 2750 6380 { lab=VLX}
N 2145 6440 2280 6440 { lab=Vout}
N 2280 6440 2430 6440 { lab=Vout}
N 2430 6440 2590 6440 { lab=Vout}
N 2590 6440 2750 6440 { lab=Vout}
N 2185 6410 2185 6485 { lab=Vg}
N 2185 6485 2320 6485 { lab=Vg}
N 2320 6410 2320 6485 { lab=Vg}
N 2320 6485 2475 6485 { lab=Vg}
N 2790 6410 2790 6485 { lab=Vg}
N 2475 6485 2790 6485 { lab=Vg}
N 2470 6410 2470 6485 { lab=Vg}
N 2630 6410 2630 6485 { lab=Vg}
N 2145 6380 2145 6410 { lab=VLX}
N 2280 6380 2280 6410 { lab=VLX}
N 2430 6380 2430 6410 { lab=VLX}
N 2590 6380 2590 6410 { lab=VLX}
N 2750 6380 2750 6410 { lab=VLX}
N 2885 6380 3020 6380 { lab=VLX}
N 3020 6380 3170 6380 { lab=VLX}
N 3170 6380 3330 6380 { lab=VLX}
N 3330 6380 3490 6380 { lab=VLX}
N 2885 6440 3020 6440 { lab=Vout}
N 3020 6440 3170 6440 { lab=Vout}
N 3170 6440 3330 6440 { lab=Vout}
N 3330 6440 3490 6440 { lab=Vout}
N 2925 6410 2925 6485 { lab=Vg}
N 2925 6485 3060 6485 { lab=Vg}
N 3060 6410 3060 6485 { lab=Vg}
N 3060 6485 3215 6485 { lab=Vg}
N 3530 6410 3530 6485 { lab=Vg}
N 3215 6485 3530 6485 { lab=Vg}
N 3210 6410 3210 6485 { lab=Vg}
N 3370 6410 3370 6485 { lab=Vg}
N 2885 6380 2885 6410 { lab=VLX}
N 3020 6380 3020 6410 { lab=VLX}
N 3170 6380 3170 6410 { lab=VLX}
N 3330 6380 3330 6410 { lab=VLX}
N 3490 6380 3490 6410 { lab=VLX}
N 2750 6380 2885 6380 { lab=VLX}
N 2750 6440 2885 6440 { lab=Vout}
N 2790 6485 2925 6485 { lab=Vg}
N 1995 6380 2145 6380 { lab=VLX}
N 2035 6485 2185 6485 { lab=Vg}
N 1995 6440 2145 6440 { lab=Vout}
N 3530 6320 3530 6410 { lab=Vg}
N 405 6215 650 6215 { lab=VLX}
N 400 6380 650 6380 { lab=VLX}
N 400 6215 400 6380 { lab=VLX}
N 400 6215 405 6215 { lab=VLX}
N 520 6275 650 6275 { lab=Vout}
N 520 6275 520 6485 { lab=Vout}
N 650 6565 785 6565 { lab=VLX}
N 785 6565 935 6565 { lab=VLX}
N 935 6565 1095 6565 { lab=VLX}
N 1095 6565 1255 6565 { lab=VLX}
N 650 6625 785 6625 { lab=Vout}
N 785 6625 935 6625 { lab=Vout}
N 935 6625 1095 6625 { lab=Vout}
N 1095 6625 1255 6625 { lab=Vout}
N 690 6595 690 6670 { lab=Vg}
N 690 6670 825 6670 { lab=Vg}
N 825 6595 825 6670 { lab=Vg}
N 825 6670 980 6670 { lab=Vg}
N 1295 6595 1295 6670 { lab=Vg}
N 980 6670 1295 6670 { lab=Vg}
N 975 6595 975 6670 { lab=Vg}
N 1135 6595 1135 6670 { lab=Vg}
N 650 6565 650 6595 { lab=VLX}
N 785 6565 785 6595 { lab=VLX}
N 935 6565 935 6595 { lab=VLX}
N 1095 6565 1095 6595 { lab=VLX}
N 1255 6565 1255 6595 { lab=VLX}
N 1390 6565 1525 6565 { lab=VLX}
N 1525 6565 1675 6565 { lab=VLX}
N 1675 6565 1835 6565 { lab=VLX}
N 1835 6565 1995 6565 { lab=VLX}
N 1390 6625 1525 6625 { lab=Vout}
N 1525 6625 1675 6625 { lab=Vout}
N 1675 6625 1835 6625 { lab=Vout}
N 1835 6625 1995 6625 { lab=Vout}
N 1430 6595 1430 6670 { lab=Vg}
N 1430 6670 1565 6670 { lab=Vg}
N 1565 6595 1565 6670 { lab=Vg}
N 1565 6670 1720 6670 { lab=Vg}
N 2035 6595 2035 6670 { lab=Vg}
N 1720 6670 2035 6670 { lab=Vg}
N 1715 6595 1715 6670 { lab=Vg}
N 1875 6595 1875 6670 { lab=Vg}
N 1390 6565 1390 6595 { lab=VLX}
N 1525 6565 1525 6595 { lab=VLX}
N 1675 6565 1675 6595 { lab=VLX}
N 1835 6565 1835 6595 { lab=VLX}
N 1995 6565 1995 6595 { lab=VLX}
N 1255 6565 1390 6565 { lab=VLX}
N 1255 6625 1390 6625 { lab=Vout}
N 1295 6670 1430 6670 { lab=Vg}
N 2145 6565 2280 6565 { lab=VLX}
N 2280 6565 2430 6565 { lab=VLX}
N 2430 6565 2590 6565 { lab=VLX}
N 2590 6565 2750 6565 { lab=VLX}
N 2145 6625 2280 6625 { lab=Vout}
N 2280 6625 2430 6625 { lab=Vout}
N 2430 6625 2590 6625 { lab=Vout}
N 2590 6625 2750 6625 { lab=Vout}
N 2185 6595 2185 6670 { lab=Vg}
N 2185 6670 2320 6670 { lab=Vg}
N 2320 6595 2320 6670 { lab=Vg}
N 2320 6670 2475 6670 { lab=Vg}
N 2790 6595 2790 6670 { lab=Vg}
N 2475 6670 2790 6670 { lab=Vg}
N 2470 6595 2470 6670 { lab=Vg}
N 2630 6595 2630 6670 { lab=Vg}
N 2145 6565 2145 6595 { lab=VLX}
N 2280 6565 2280 6595 { lab=VLX}
N 2430 6565 2430 6595 { lab=VLX}
N 2590 6565 2590 6595 { lab=VLX}
N 2750 6565 2750 6595 { lab=VLX}
N 2885 6565 3020 6565 { lab=VLX}
N 3020 6565 3170 6565 { lab=VLX}
N 3170 6565 3330 6565 { lab=VLX}
N 3330 6565 3490 6565 { lab=VLX}
N 2885 6625 3020 6625 { lab=Vout}
N 3020 6625 3170 6625 { lab=Vout}
N 3170 6625 3330 6625 { lab=Vout}
N 3330 6625 3490 6625 { lab=Vout}
N 2925 6595 2925 6670 { lab=Vg}
N 2925 6670 3060 6670 { lab=Vg}
N 3060 6595 3060 6670 { lab=Vg}
N 3060 6670 3215 6670 { lab=Vg}
N 3530 6595 3530 6670 { lab=Vg}
N 3215 6670 3530 6670 { lab=Vg}
N 3210 6595 3210 6670 { lab=Vg}
N 3370 6595 3370 6670 { lab=Vg}
N 2885 6565 2885 6595 { lab=VLX}
N 3020 6565 3020 6595 { lab=VLX}
N 3170 6565 3170 6595 { lab=VLX}
N 3330 6565 3330 6595 { lab=VLX}
N 3490 6565 3490 6595 { lab=VLX}
N 2750 6565 2885 6565 { lab=VLX}
N 2750 6625 2885 6625 { lab=Vout}
N 2790 6670 2925 6670 { lab=Vg}
N 1995 6565 2145 6565 { lab=VLX}
N 2035 6670 2185 6670 { lab=Vg}
N 1995 6625 2145 6625 { lab=Vout}
N 650 6730 785 6730 { lab=VLX}
N 785 6730 935 6730 { lab=VLX}
N 935 6730 1095 6730 { lab=VLX}
N 1095 6730 1255 6730 { lab=VLX}
N 650 6790 785 6790 { lab=Vout}
N 785 6790 935 6790 { lab=Vout}
N 935 6790 1095 6790 { lab=Vout}
N 1095 6790 1255 6790 { lab=Vout}
N 690 6760 690 6835 { lab=Vg}
N 690 6835 825 6835 { lab=Vg}
N 825 6760 825 6835 { lab=Vg}
N 825 6835 980 6835 { lab=Vg}
N 1295 6760 1295 6835 { lab=Vg}
N 980 6835 1295 6835 { lab=Vg}
N 975 6760 975 6835 { lab=Vg}
N 1135 6760 1135 6835 { lab=Vg}
N 650 6730 650 6760 { lab=VLX}
N 785 6730 785 6760 { lab=VLX}
N 935 6730 935 6760 { lab=VLX}
N 1095 6730 1095 6760 { lab=VLX}
N 1255 6730 1255 6760 { lab=VLX}
N 1390 6730 1525 6730 { lab=VLX}
N 1525 6730 1675 6730 { lab=VLX}
N 1675 6730 1835 6730 { lab=VLX}
N 1835 6730 1995 6730 { lab=VLX}
N 1390 6790 1525 6790 { lab=Vout}
N 1525 6790 1675 6790 { lab=Vout}
N 1675 6790 1835 6790 { lab=Vout}
N 1835 6790 1995 6790 { lab=Vout}
N 1430 6760 1430 6835 { lab=Vg}
N 1430 6835 1565 6835 { lab=Vg}
N 1565 6760 1565 6835 { lab=Vg}
N 1565 6835 1720 6835 { lab=Vg}
N 2035 6760 2035 6835 { lab=Vg}
N 1720 6835 2035 6835 { lab=Vg}
N 1715 6760 1715 6835 { lab=Vg}
N 1875 6760 1875 6835 { lab=Vg}
N 1390 6730 1390 6760 { lab=VLX}
N 1525 6730 1525 6760 { lab=VLX}
N 1675 6730 1675 6760 { lab=VLX}
N 1835 6730 1835 6760 { lab=VLX}
N 1995 6730 1995 6760 { lab=VLX}
N 1255 6730 1390 6730 { lab=VLX}
N 1255 6790 1390 6790 { lab=Vout}
N 1295 6835 1430 6835 { lab=Vg}
N 2145 6730 2280 6730 { lab=VLX}
N 2280 6730 2430 6730 { lab=VLX}
N 2430 6730 2590 6730 { lab=VLX}
N 2590 6730 2750 6730 { lab=VLX}
N 2145 6790 2280 6790 { lab=Vout}
N 2280 6790 2430 6790 { lab=Vout}
N 2430 6790 2590 6790 { lab=Vout}
N 2590 6790 2750 6790 { lab=Vout}
N 2185 6760 2185 6835 { lab=Vg}
N 2185 6835 2320 6835 { lab=Vg}
N 2320 6760 2320 6835 { lab=Vg}
N 2320 6835 2475 6835 { lab=Vg}
N 2790 6760 2790 6835 { lab=Vg}
N 2475 6835 2790 6835 { lab=Vg}
N 2470 6760 2470 6835 { lab=Vg}
N 2630 6760 2630 6835 { lab=Vg}
N 2145 6730 2145 6760 { lab=VLX}
N 2280 6730 2280 6760 { lab=VLX}
N 2430 6730 2430 6760 { lab=VLX}
N 2590 6730 2590 6760 { lab=VLX}
N 2750 6730 2750 6760 { lab=VLX}
N 2885 6730 3020 6730 { lab=VLX}
N 3020 6730 3170 6730 { lab=VLX}
N 3170 6730 3330 6730 { lab=VLX}
N 3330 6730 3490 6730 { lab=VLX}
N 2885 6790 3020 6790 { lab=Vout}
N 3020 6790 3170 6790 { lab=Vout}
N 3170 6790 3330 6790 { lab=Vout}
N 3330 6790 3490 6790 { lab=Vout}
N 2925 6760 2925 6835 { lab=Vg}
N 2925 6835 3060 6835 { lab=Vg}
N 3060 6760 3060 6835 { lab=Vg}
N 3060 6835 3215 6835 { lab=Vg}
N 3530 6760 3530 6835 { lab=Vg}
N 3215 6835 3530 6835 { lab=Vg}
N 3210 6760 3210 6835 { lab=Vg}
N 3370 6760 3370 6835 { lab=Vg}
N 2885 6730 2885 6760 { lab=VLX}
N 3020 6730 3020 6760 { lab=VLX}
N 3170 6730 3170 6760 { lab=VLX}
N 3330 6730 3330 6760 { lab=VLX}
N 3490 6730 3490 6760 { lab=VLX}
N 2750 6730 2885 6730 { lab=VLX}
N 2750 6790 2885 6790 { lab=Vout}
N 2790 6835 2925 6835 { lab=Vg}
N 1995 6730 2145 6730 { lab=VLX}
N 2035 6835 2185 6835 { lab=Vg}
N 1995 6790 2145 6790 { lab=Vout}
N 3530 6670 3530 6760 { lab=Vg}
N 405 6565 650 6565 { lab=VLX}
N 400 6730 650 6730 { lab=VLX}
N 400 6565 400 6730 { lab=VLX}
N 400 6565 405 6565 { lab=VLX}
N 520 6625 650 6625 { lab=Vout}
N 520 6625 520 6835 { lab=Vout}
N 400 6380 400 6570 { lab=VLX}
N 520 6480 520 6630 { lab=Vout}
N 3530 6480 3530 6600 { lab=Vg}
N 650 6885 785 6885 { lab=VLX}
N 785 6885 935 6885 { lab=VLX}
N 935 6885 1095 6885 { lab=VLX}
N 1095 6885 1255 6885 { lab=VLX}
N 650 6945 785 6945 { lab=Vout}
N 785 6945 935 6945 { lab=Vout}
N 935 6945 1095 6945 { lab=Vout}
N 1095 6945 1255 6945 { lab=Vout}
N 690 6915 690 6990 { lab=Vg}
N 690 6990 825 6990 { lab=Vg}
N 825 6915 825 6990 { lab=Vg}
N 825 6990 980 6990 { lab=Vg}
N 1295 6915 1295 6990 { lab=Vg}
N 980 6990 1295 6990 { lab=Vg}
N 975 6915 975 6990 { lab=Vg}
N 1135 6915 1135 6990 { lab=Vg}
N 650 6885 650 6915 { lab=VLX}
N 785 6885 785 6915 { lab=VLX}
N 935 6885 935 6915 { lab=VLX}
N 1095 6885 1095 6915 { lab=VLX}
N 1255 6885 1255 6915 { lab=VLX}
N 1390 6885 1525 6885 { lab=VLX}
N 1525 6885 1675 6885 { lab=VLX}
N 1675 6885 1835 6885 { lab=VLX}
N 1835 6885 1995 6885 { lab=VLX}
N 1390 6945 1525 6945 { lab=Vout}
N 1525 6945 1675 6945 { lab=Vout}
N 1675 6945 1835 6945 { lab=Vout}
N 1835 6945 1995 6945 { lab=Vout}
N 1430 6915 1430 6990 { lab=Vg}
N 1430 6990 1565 6990 { lab=Vg}
N 1565 6915 1565 6990 { lab=Vg}
N 1565 6990 1720 6990 { lab=Vg}
N 2035 6915 2035 6990 { lab=Vg}
N 1720 6990 2035 6990 { lab=Vg}
N 1715 6915 1715 6990 { lab=Vg}
N 1875 6915 1875 6990 { lab=Vg}
N 1390 6885 1390 6915 { lab=VLX}
N 1525 6885 1525 6915 { lab=VLX}
N 1675 6885 1675 6915 { lab=VLX}
N 1835 6885 1835 6915 { lab=VLX}
N 1995 6885 1995 6915 { lab=VLX}
N 1255 6885 1390 6885 { lab=VLX}
N 1255 6945 1390 6945 { lab=Vout}
N 1295 6990 1430 6990 { lab=Vg}
N 2145 6885 2280 6885 { lab=VLX}
N 2280 6885 2430 6885 { lab=VLX}
N 2430 6885 2590 6885 { lab=VLX}
N 2590 6885 2750 6885 { lab=VLX}
N 2145 6945 2280 6945 { lab=Vout}
N 2280 6945 2430 6945 { lab=Vout}
N 2430 6945 2590 6945 { lab=Vout}
N 2590 6945 2750 6945 { lab=Vout}
N 2185 6915 2185 6990 { lab=Vg}
N 2185 6990 2320 6990 { lab=Vg}
N 2320 6915 2320 6990 { lab=Vg}
N 2320 6990 2475 6990 { lab=Vg}
N 2790 6915 2790 6990 { lab=Vg}
N 2475 6990 2790 6990 { lab=Vg}
N 2470 6915 2470 6990 { lab=Vg}
N 2630 6915 2630 6990 { lab=Vg}
N 2145 6885 2145 6915 { lab=VLX}
N 2280 6885 2280 6915 { lab=VLX}
N 2430 6885 2430 6915 { lab=VLX}
N 2590 6885 2590 6915 { lab=VLX}
N 2750 6885 2750 6915 { lab=VLX}
N 2885 6885 3020 6885 { lab=VLX}
N 3020 6885 3170 6885 { lab=VLX}
N 3170 6885 3330 6885 { lab=VLX}
N 3330 6885 3490 6885 { lab=VLX}
N 2885 6945 3020 6945 { lab=Vout}
N 3020 6945 3170 6945 { lab=Vout}
N 3170 6945 3330 6945 { lab=Vout}
N 3330 6945 3490 6945 { lab=Vout}
N 2925 6915 2925 6990 { lab=Vg}
N 2925 6990 3060 6990 { lab=Vg}
N 3060 6915 3060 6990 { lab=Vg}
N 3060 6990 3215 6990 { lab=Vg}
N 3530 6915 3530 6990 { lab=Vg}
N 3215 6990 3530 6990 { lab=Vg}
N 3210 6915 3210 6990 { lab=Vg}
N 3370 6915 3370 6990 { lab=Vg}
N 2885 6885 2885 6915 { lab=VLX}
N 3020 6885 3020 6915 { lab=VLX}
N 3170 6885 3170 6915 { lab=VLX}
N 3330 6885 3330 6915 { lab=VLX}
N 3490 6885 3490 6915 { lab=VLX}
N 2750 6885 2885 6885 { lab=VLX}
N 2750 6945 2885 6945 { lab=Vout}
N 2790 6990 2925 6990 { lab=Vg}
N 1995 6885 2145 6885 { lab=VLX}
N 2035 6990 2185 6990 { lab=Vg}
N 1995 6945 2145 6945 { lab=Vout}
N 650 7050 785 7050 { lab=VLX}
N 785 7050 935 7050 { lab=VLX}
N 935 7050 1095 7050 { lab=VLX}
N 1095 7050 1255 7050 { lab=VLX}
N 650 7110 785 7110 { lab=Vout}
N 785 7110 935 7110 { lab=Vout}
N 935 7110 1095 7110 { lab=Vout}
N 1095 7110 1255 7110 { lab=Vout}
N 690 7080 690 7155 { lab=Vg}
N 690 7155 825 7155 { lab=Vg}
N 825 7080 825 7155 { lab=Vg}
N 825 7155 980 7155 { lab=Vg}
N 1295 7080 1295 7155 { lab=Vg}
N 980 7155 1295 7155 { lab=Vg}
N 975 7080 975 7155 { lab=Vg}
N 1135 7080 1135 7155 { lab=Vg}
N 650 7050 650 7080 { lab=VLX}
N 785 7050 785 7080 { lab=VLX}
N 935 7050 935 7080 { lab=VLX}
N 1095 7050 1095 7080 { lab=VLX}
N 1255 7050 1255 7080 { lab=VLX}
N 1390 7050 1525 7050 { lab=VLX}
N 1525 7050 1675 7050 { lab=VLX}
N 1675 7050 1835 7050 { lab=VLX}
N 1835 7050 1995 7050 { lab=VLX}
N 1390 7110 1525 7110 { lab=Vout}
N 1525 7110 1675 7110 { lab=Vout}
N 1675 7110 1835 7110 { lab=Vout}
N 1835 7110 1995 7110 { lab=Vout}
N 1430 7080 1430 7155 { lab=Vg}
N 1430 7155 1565 7155 { lab=Vg}
N 1565 7080 1565 7155 { lab=Vg}
N 1565 7155 1720 7155 { lab=Vg}
N 2035 7080 2035 7155 { lab=Vg}
N 1720 7155 2035 7155 { lab=Vg}
N 1715 7080 1715 7155 { lab=Vg}
N 1875 7080 1875 7155 { lab=Vg}
N 1390 7050 1390 7080 { lab=VLX}
N 1525 7050 1525 7080 { lab=VLX}
N 1675 7050 1675 7080 { lab=VLX}
N 1835 7050 1835 7080 { lab=VLX}
N 1995 7050 1995 7080 { lab=VLX}
N 1255 7050 1390 7050 { lab=VLX}
N 1255 7110 1390 7110 { lab=Vout}
N 1295 7155 1430 7155 { lab=Vg}
N 2145 7050 2280 7050 { lab=VLX}
N 2280 7050 2430 7050 { lab=VLX}
N 2430 7050 2590 7050 { lab=VLX}
N 2590 7050 2750 7050 { lab=VLX}
N 2145 7110 2280 7110 { lab=Vout}
N 2280 7110 2430 7110 { lab=Vout}
N 2430 7110 2590 7110 { lab=Vout}
N 2590 7110 2750 7110 { lab=Vout}
N 2185 7080 2185 7155 { lab=Vg}
N 2185 7155 2320 7155 { lab=Vg}
N 2320 7080 2320 7155 { lab=Vg}
N 2320 7155 2475 7155 { lab=Vg}
N 2790 7080 2790 7155 { lab=Vg}
N 2475 7155 2790 7155 { lab=Vg}
N 2470 7080 2470 7155 { lab=Vg}
N 2630 7080 2630 7155 { lab=Vg}
N 2145 7050 2145 7080 { lab=VLX}
N 2280 7050 2280 7080 { lab=VLX}
N 2430 7050 2430 7080 { lab=VLX}
N 2590 7050 2590 7080 { lab=VLX}
N 2750 7050 2750 7080 { lab=VLX}
N 2885 7050 3020 7050 { lab=VLX}
N 3020 7050 3170 7050 { lab=VLX}
N 3170 7050 3330 7050 { lab=VLX}
N 3330 7050 3490 7050 { lab=VLX}
N 2885 7110 3020 7110 { lab=Vout}
N 3020 7110 3170 7110 { lab=Vout}
N 3170 7110 3330 7110 { lab=Vout}
N 3330 7110 3490 7110 { lab=Vout}
N 2925 7080 2925 7155 { lab=Vg}
N 2925 7155 3060 7155 { lab=Vg}
N 3060 7080 3060 7155 { lab=Vg}
N 3060 7155 3215 7155 { lab=Vg}
N 3530 7080 3530 7155 { lab=Vg}
N 3215 7155 3530 7155 { lab=Vg}
N 3210 7080 3210 7155 { lab=Vg}
N 3370 7080 3370 7155 { lab=Vg}
N 2885 7050 2885 7080 { lab=VLX}
N 3020 7050 3020 7080 { lab=VLX}
N 3170 7050 3170 7080 { lab=VLX}
N 3330 7050 3330 7080 { lab=VLX}
N 3490 7050 3490 7080 { lab=VLX}
N 2750 7050 2885 7050 { lab=VLX}
N 2750 7110 2885 7110 { lab=Vout}
N 2790 7155 2925 7155 { lab=Vg}
N 1995 7050 2145 7050 { lab=VLX}
N 2035 7155 2185 7155 { lab=Vg}
N 1995 7110 2145 7110 { lab=Vout}
N 3530 6990 3530 7080 { lab=Vg}
N 405 6885 650 6885 { lab=VLX}
N 400 7050 650 7050 { lab=VLX}
N 400 6885 400 7050 { lab=VLX}
N 400 6885 405 6885 { lab=VLX}
N 520 6945 650 6945 { lab=Vout}
N 520 6945 520 7155 { lab=Vout}
N 650 7235 785 7235 { lab=VLX}
N 785 7235 935 7235 { lab=VLX}
N 935 7235 1095 7235 { lab=VLX}
N 1095 7235 1255 7235 { lab=VLX}
N 650 7295 785 7295 { lab=Vout}
N 785 7295 935 7295 { lab=Vout}
N 935 7295 1095 7295 { lab=Vout}
N 1095 7295 1255 7295 { lab=Vout}
N 690 7265 690 7340 { lab=Vg}
N 690 7340 825 7340 { lab=Vg}
N 825 7265 825 7340 { lab=Vg}
N 825 7340 980 7340 { lab=Vg}
N 1295 7265 1295 7340 { lab=Vg}
N 980 7340 1295 7340 { lab=Vg}
N 975 7265 975 7340 { lab=Vg}
N 1135 7265 1135 7340 { lab=Vg}
N 650 7235 650 7265 { lab=VLX}
N 785 7235 785 7265 { lab=VLX}
N 935 7235 935 7265 { lab=VLX}
N 1095 7235 1095 7265 { lab=VLX}
N 1255 7235 1255 7265 { lab=VLX}
N 1390 7235 1525 7235 { lab=VLX}
N 1525 7235 1675 7235 { lab=VLX}
N 1675 7235 1835 7235 { lab=VLX}
N 1835 7235 1995 7235 { lab=VLX}
N 1390 7295 1525 7295 { lab=Vout}
N 1525 7295 1675 7295 { lab=Vout}
N 1675 7295 1835 7295 { lab=Vout}
N 1835 7295 1995 7295 { lab=Vout}
N 1430 7265 1430 7340 { lab=Vg}
N 1430 7340 1565 7340 { lab=Vg}
N 1565 7265 1565 7340 { lab=Vg}
N 1565 7340 1720 7340 { lab=Vg}
N 2035 7265 2035 7340 { lab=Vg}
N 1720 7340 2035 7340 { lab=Vg}
N 1715 7265 1715 7340 { lab=Vg}
N 1875 7265 1875 7340 { lab=Vg}
N 1390 7235 1390 7265 { lab=VLX}
N 1525 7235 1525 7265 { lab=VLX}
N 1675 7235 1675 7265 { lab=VLX}
N 1835 7235 1835 7265 { lab=VLX}
N 1995 7235 1995 7265 { lab=VLX}
N 1255 7235 1390 7235 { lab=VLX}
N 1255 7295 1390 7295 { lab=Vout}
N 1295 7340 1430 7340 { lab=Vg}
N 2145 7235 2280 7235 { lab=VLX}
N 2280 7235 2430 7235 { lab=VLX}
N 2430 7235 2590 7235 { lab=VLX}
N 2590 7235 2750 7235 { lab=VLX}
N 2145 7295 2280 7295 { lab=Vout}
N 2280 7295 2430 7295 { lab=Vout}
N 2430 7295 2590 7295 { lab=Vout}
N 2590 7295 2750 7295 { lab=Vout}
N 2185 7265 2185 7340 { lab=Vg}
N 2185 7340 2320 7340 { lab=Vg}
N 2320 7265 2320 7340 { lab=Vg}
N 2320 7340 2475 7340 { lab=Vg}
N 2790 7265 2790 7340 { lab=Vg}
N 2475 7340 2790 7340 { lab=Vg}
N 2470 7265 2470 7340 { lab=Vg}
N 2630 7265 2630 7340 { lab=Vg}
N 2145 7235 2145 7265 { lab=VLX}
N 2280 7235 2280 7265 { lab=VLX}
N 2430 7235 2430 7265 { lab=VLX}
N 2590 7235 2590 7265 { lab=VLX}
N 2750 7235 2750 7265 { lab=VLX}
N 2885 7235 3020 7235 { lab=VLX}
N 3020 7235 3170 7235 { lab=VLX}
N 3170 7235 3330 7235 { lab=VLX}
N 3330 7235 3490 7235 { lab=VLX}
N 2885 7295 3020 7295 { lab=Vout}
N 3020 7295 3170 7295 { lab=Vout}
N 3170 7295 3330 7295 { lab=Vout}
N 3330 7295 3490 7295 { lab=Vout}
N 2925 7265 2925 7340 { lab=Vg}
N 2925 7340 3060 7340 { lab=Vg}
N 3060 7265 3060 7340 { lab=Vg}
N 3060 7340 3215 7340 { lab=Vg}
N 3530 7265 3530 7340 { lab=Vg}
N 3215 7340 3530 7340 { lab=Vg}
N 3210 7265 3210 7340 { lab=Vg}
N 3370 7265 3370 7340 { lab=Vg}
N 2885 7235 2885 7265 { lab=VLX}
N 3020 7235 3020 7265 { lab=VLX}
N 3170 7235 3170 7265 { lab=VLX}
N 3330 7235 3330 7265 { lab=VLX}
N 3490 7235 3490 7265 { lab=VLX}
N 2750 7235 2885 7235 { lab=VLX}
N 2750 7295 2885 7295 { lab=Vout}
N 2790 7340 2925 7340 { lab=Vg}
N 1995 7235 2145 7235 { lab=VLX}
N 2035 7340 2185 7340 { lab=Vg}
N 1995 7295 2145 7295 { lab=Vout}
N 650 7400 785 7400 { lab=VLX}
N 785 7400 935 7400 { lab=VLX}
N 935 7400 1095 7400 { lab=VLX}
N 1095 7400 1255 7400 { lab=VLX}
N 650 7460 785 7460 { lab=Vout}
N 785 7460 935 7460 { lab=Vout}
N 935 7460 1095 7460 { lab=Vout}
N 1095 7460 1255 7460 { lab=Vout}
N 690 7430 690 7505 { lab=Vg}
N 690 7505 825 7505 { lab=Vg}
N 825 7430 825 7505 { lab=Vg}
N 825 7505 980 7505 { lab=Vg}
N 1295 7430 1295 7505 { lab=Vg}
N 980 7505 1295 7505 { lab=Vg}
N 975 7430 975 7505 { lab=Vg}
N 1135 7430 1135 7505 { lab=Vg}
N 650 7400 650 7430 { lab=VLX}
N 785 7400 785 7430 { lab=VLX}
N 935 7400 935 7430 { lab=VLX}
N 1095 7400 1095 7430 { lab=VLX}
N 1255 7400 1255 7430 { lab=VLX}
N 1390 7400 1525 7400 { lab=VLX}
N 1525 7400 1675 7400 { lab=VLX}
N 1675 7400 1835 7400 { lab=VLX}
N 1835 7400 1995 7400 { lab=VLX}
N 1390 7460 1525 7460 { lab=Vout}
N 1525 7460 1675 7460 { lab=Vout}
N 1675 7460 1835 7460 { lab=Vout}
N 1835 7460 1995 7460 { lab=Vout}
N 1430 7430 1430 7505 { lab=Vg}
N 1430 7505 1565 7505 { lab=Vg}
N 1565 7430 1565 7505 { lab=Vg}
N 1565 7505 1720 7505 { lab=Vg}
N 2035 7430 2035 7505 { lab=Vg}
N 1720 7505 2035 7505 { lab=Vg}
N 1715 7430 1715 7505 { lab=Vg}
N 1875 7430 1875 7505 { lab=Vg}
N 1390 7400 1390 7430 { lab=VLX}
N 1525 7400 1525 7430 { lab=VLX}
N 1675 7400 1675 7430 { lab=VLX}
N 1835 7400 1835 7430 { lab=VLX}
N 1995 7400 1995 7430 { lab=VLX}
N 1255 7400 1390 7400 { lab=VLX}
N 1255 7460 1390 7460 { lab=Vout}
N 1295 7505 1430 7505 { lab=Vg}
N 2145 7400 2280 7400 { lab=VLX}
N 2280 7400 2430 7400 { lab=VLX}
N 2430 7400 2590 7400 { lab=VLX}
N 2590 7400 2750 7400 { lab=VLX}
N 2145 7460 2280 7460 { lab=Vout}
N 2280 7460 2430 7460 { lab=Vout}
N 2430 7460 2590 7460 { lab=Vout}
N 2590 7460 2750 7460 { lab=Vout}
N 2185 7430 2185 7505 { lab=Vg}
N 2185 7505 2320 7505 { lab=Vg}
N 2320 7430 2320 7505 { lab=Vg}
N 2320 7505 2475 7505 { lab=Vg}
N 2790 7430 2790 7505 { lab=Vg}
N 2475 7505 2790 7505 { lab=Vg}
N 2470 7430 2470 7505 { lab=Vg}
N 2630 7430 2630 7505 { lab=Vg}
N 2145 7400 2145 7430 { lab=VLX}
N 2280 7400 2280 7430 { lab=VLX}
N 2430 7400 2430 7430 { lab=VLX}
N 2590 7400 2590 7430 { lab=VLX}
N 2750 7400 2750 7430 { lab=VLX}
N 2885 7400 3020 7400 { lab=VLX}
N 3020 7400 3170 7400 { lab=VLX}
N 3170 7400 3330 7400 { lab=VLX}
N 3330 7400 3490 7400 { lab=VLX}
N 2885 7460 3020 7460 { lab=Vout}
N 3020 7460 3170 7460 { lab=Vout}
N 3170 7460 3330 7460 { lab=Vout}
N 3330 7460 3490 7460 { lab=Vout}
N 2925 7430 2925 7505 { lab=Vg}
N 2925 7505 3060 7505 { lab=Vg}
N 3060 7430 3060 7505 { lab=Vg}
N 3060 7505 3215 7505 { lab=Vg}
N 3530 7430 3530 7505 { lab=Vg}
N 3215 7505 3530 7505 { lab=Vg}
N 3210 7430 3210 7505 { lab=Vg}
N 3370 7430 3370 7505 { lab=Vg}
N 2885 7400 2885 7430 { lab=VLX}
N 3020 7400 3020 7430 { lab=VLX}
N 3170 7400 3170 7430 { lab=VLX}
N 3330 7400 3330 7430 { lab=VLX}
N 3490 7400 3490 7430 { lab=VLX}
N 2750 7400 2885 7400 { lab=VLX}
N 2750 7460 2885 7460 { lab=Vout}
N 2790 7505 2925 7505 { lab=Vg}
N 1995 7400 2145 7400 { lab=VLX}
N 2035 7505 2185 7505 { lab=Vg}
N 1995 7460 2145 7460 { lab=Vout}
N 3530 7340 3530 7430 { lab=Vg}
N 405 7235 650 7235 { lab=VLX}
N 400 7400 650 7400 { lab=VLX}
N 400 7235 400 7400 { lab=VLX}
N 400 7235 405 7235 { lab=VLX}
N 520 7295 650 7295 { lab=Vout}
N 520 7295 520 7505 { lab=Vout}
N 400 7050 400 7240 { lab=VLX}
N 520 7150 520 7300 { lab=Vout}
N 3530 7150 3530 7270 { lab=Vg}
N 400 6730 400 6890 { lab=VLX}
N 520 6830 520 6950 { lab=Vout}
N 3530 6840 3530 6910 { lab=Vg}
N 3530 6830 3530 6840 { lab=Vg}
N 650 7635 785 7635 { lab=VLX}
N 785 7635 935 7635 { lab=VLX}
N 935 7635 1095 7635 { lab=VLX}
N 1095 7635 1255 7635 { lab=VLX}
N 650 7695 785 7695 { lab=Vout}
N 785 7695 935 7695 { lab=Vout}
N 935 7695 1095 7695 { lab=Vout}
N 1095 7695 1255 7695 { lab=Vout}
N 690 7665 690 7740 { lab=Vg}
N 690 7740 825 7740 { lab=Vg}
N 825 7665 825 7740 { lab=Vg}
N 825 7740 980 7740 { lab=Vg}
N 1295 7665 1295 7740 { lab=Vg}
N 980 7740 1295 7740 { lab=Vg}
N 975 7665 975 7740 { lab=Vg}
N 1135 7665 1135 7740 { lab=Vg}
N 650 7635 650 7665 { lab=VLX}
N 785 7635 785 7665 { lab=VLX}
N 935 7635 935 7665 { lab=VLX}
N 1095 7635 1095 7665 { lab=VLX}
N 1255 7635 1255 7665 { lab=VLX}
N 1390 7635 1525 7635 { lab=VLX}
N 1525 7635 1675 7635 { lab=VLX}
N 1675 7635 1835 7635 { lab=VLX}
N 1835 7635 1995 7635 { lab=VLX}
N 1390 7695 1525 7695 { lab=Vout}
N 1525 7695 1675 7695 { lab=Vout}
N 1675 7695 1835 7695 { lab=Vout}
N 1835 7695 1995 7695 { lab=Vout}
N 1430 7665 1430 7740 { lab=Vg}
N 1430 7740 1565 7740 { lab=Vg}
N 1565 7665 1565 7740 { lab=Vg}
N 1565 7740 1720 7740 { lab=Vg}
N 2035 7665 2035 7740 { lab=Vg}
N 1720 7740 2035 7740 { lab=Vg}
N 1715 7665 1715 7740 { lab=Vg}
N 1875 7665 1875 7740 { lab=Vg}
N 1390 7635 1390 7665 { lab=VLX}
N 1525 7635 1525 7665 { lab=VLX}
N 1675 7635 1675 7665 { lab=VLX}
N 1835 7635 1835 7665 { lab=VLX}
N 1995 7635 1995 7665 { lab=VLX}
N 1255 7635 1390 7635 { lab=VLX}
N 1255 7695 1390 7695 { lab=Vout}
N 1295 7740 1430 7740 { lab=Vg}
N 2145 7635 2280 7635 { lab=VLX}
N 2280 7635 2430 7635 { lab=VLX}
N 2430 7635 2590 7635 { lab=VLX}
N 2590 7635 2750 7635 { lab=VLX}
N 2145 7695 2280 7695 { lab=Vout}
N 2280 7695 2430 7695 { lab=Vout}
N 2430 7695 2590 7695 { lab=Vout}
N 2590 7695 2750 7695 { lab=Vout}
N 2185 7665 2185 7740 { lab=Vg}
N 2185 7740 2320 7740 { lab=Vg}
N 2320 7665 2320 7740 { lab=Vg}
N 2320 7740 2475 7740 { lab=Vg}
N 2790 7665 2790 7740 { lab=Vg}
N 2475 7740 2790 7740 { lab=Vg}
N 2470 7665 2470 7740 { lab=Vg}
N 2630 7665 2630 7740 { lab=Vg}
N 2145 7635 2145 7665 { lab=VLX}
N 2280 7635 2280 7665 { lab=VLX}
N 2430 7635 2430 7665 { lab=VLX}
N 2590 7635 2590 7665 { lab=VLX}
N 2750 7635 2750 7665 { lab=VLX}
N 2885 7635 3020 7635 { lab=VLX}
N 3020 7635 3170 7635 { lab=VLX}
N 3170 7635 3330 7635 { lab=VLX}
N 3330 7635 3490 7635 { lab=VLX}
N 2885 7695 3020 7695 { lab=Vout}
N 3020 7695 3170 7695 { lab=Vout}
N 3170 7695 3330 7695 { lab=Vout}
N 3330 7695 3490 7695 { lab=Vout}
N 2925 7665 2925 7740 { lab=Vg}
N 2925 7740 3060 7740 { lab=Vg}
N 3060 7665 3060 7740 { lab=Vg}
N 3060 7740 3215 7740 { lab=Vg}
N 3530 7665 3530 7740 { lab=Vg}
N 3215 7740 3530 7740 { lab=Vg}
N 3210 7665 3210 7740 { lab=Vg}
N 3370 7665 3370 7740 { lab=Vg}
N 2885 7635 2885 7665 { lab=VLX}
N 3020 7635 3020 7665 { lab=VLX}
N 3170 7635 3170 7665 { lab=VLX}
N 3330 7635 3330 7665 { lab=VLX}
N 3490 7635 3490 7665 { lab=VLX}
N 2750 7635 2885 7635 { lab=VLX}
N 2750 7695 2885 7695 { lab=Vout}
N 2790 7740 2925 7740 { lab=Vg}
N 1995 7635 2145 7635 { lab=VLX}
N 2035 7740 2185 7740 { lab=Vg}
N 1995 7695 2145 7695 { lab=Vout}
N 650 7800 785 7800 { lab=VLX}
N 785 7800 935 7800 { lab=VLX}
N 935 7800 1095 7800 { lab=VLX}
N 1095 7800 1255 7800 { lab=VLX}
N 650 7860 785 7860 { lab=Vout}
N 785 7860 935 7860 { lab=Vout}
N 935 7860 1095 7860 { lab=Vout}
N 1095 7860 1255 7860 { lab=Vout}
N 690 7830 690 7905 { lab=Vg}
N 690 7905 825 7905 { lab=Vg}
N 825 7830 825 7905 { lab=Vg}
N 825 7905 980 7905 { lab=Vg}
N 1295 7830 1295 7905 { lab=Vg}
N 980 7905 1295 7905 { lab=Vg}
N 975 7830 975 7905 { lab=Vg}
N 1135 7830 1135 7905 { lab=Vg}
N 650 7800 650 7830 { lab=VLX}
N 785 7800 785 7830 { lab=VLX}
N 935 7800 935 7830 { lab=VLX}
N 1095 7800 1095 7830 { lab=VLX}
N 1255 7800 1255 7830 { lab=VLX}
N 1390 7800 1525 7800 { lab=VLX}
N 1525 7800 1675 7800 { lab=VLX}
N 1675 7800 1835 7800 { lab=VLX}
N 1835 7800 1995 7800 { lab=VLX}
N 1390 7860 1525 7860 { lab=Vout}
N 1525 7860 1675 7860 { lab=Vout}
N 1675 7860 1835 7860 { lab=Vout}
N 1835 7860 1995 7860 { lab=Vout}
N 1430 7830 1430 7905 { lab=Vg}
N 1430 7905 1565 7905 { lab=Vg}
N 1565 7830 1565 7905 { lab=Vg}
N 1565 7905 1720 7905 { lab=Vg}
N 2035 7830 2035 7905 { lab=Vg}
N 1720 7905 2035 7905 { lab=Vg}
N 1715 7830 1715 7905 { lab=Vg}
N 1875 7830 1875 7905 { lab=Vg}
N 1390 7800 1390 7830 { lab=VLX}
N 1525 7800 1525 7830 { lab=VLX}
N 1675 7800 1675 7830 { lab=VLX}
N 1835 7800 1835 7830 { lab=VLX}
N 1995 7800 1995 7830 { lab=VLX}
N 1255 7800 1390 7800 { lab=VLX}
N 1255 7860 1390 7860 { lab=Vout}
N 1295 7905 1430 7905 { lab=Vg}
N 2145 7800 2280 7800 { lab=VLX}
N 2280 7800 2430 7800 { lab=VLX}
N 2430 7800 2590 7800 { lab=VLX}
N 2590 7800 2750 7800 { lab=VLX}
N 2145 7860 2280 7860 { lab=Vout}
N 2280 7860 2430 7860 { lab=Vout}
N 2430 7860 2590 7860 { lab=Vout}
N 2590 7860 2750 7860 { lab=Vout}
N 2185 7830 2185 7905 { lab=Vg}
N 2185 7905 2320 7905 { lab=Vg}
N 2320 7830 2320 7905 { lab=Vg}
N 2320 7905 2475 7905 { lab=Vg}
N 2790 7830 2790 7905 { lab=Vg}
N 2475 7905 2790 7905 { lab=Vg}
N 2470 7830 2470 7905 { lab=Vg}
N 2630 7830 2630 7905 { lab=Vg}
N 2145 7800 2145 7830 { lab=VLX}
N 2280 7800 2280 7830 { lab=VLX}
N 2430 7800 2430 7830 { lab=VLX}
N 2590 7800 2590 7830 { lab=VLX}
N 2750 7800 2750 7830 { lab=VLX}
N 2885 7800 3020 7800 { lab=VLX}
N 3020 7800 3170 7800 { lab=VLX}
N 3170 7800 3330 7800 { lab=VLX}
N 3330 7800 3490 7800 { lab=VLX}
N 2885 7860 3020 7860 { lab=Vout}
N 3020 7860 3170 7860 { lab=Vout}
N 3170 7860 3330 7860 { lab=Vout}
N 3330 7860 3490 7860 { lab=Vout}
N 2925 7830 2925 7905 { lab=Vg}
N 2925 7905 3060 7905 { lab=Vg}
N 3060 7830 3060 7905 { lab=Vg}
N 3060 7905 3215 7905 { lab=Vg}
N 3530 7830 3530 7905 { lab=Vg}
N 3215 7905 3530 7905 { lab=Vg}
N 3210 7830 3210 7905 { lab=Vg}
N 3370 7830 3370 7905 { lab=Vg}
N 2885 7800 2885 7830 { lab=VLX}
N 3020 7800 3020 7830 { lab=VLX}
N 3170 7800 3170 7830 { lab=VLX}
N 3330 7800 3330 7830 { lab=VLX}
N 3490 7800 3490 7830 { lab=VLX}
N 2750 7800 2885 7800 { lab=VLX}
N 2750 7860 2885 7860 { lab=Vout}
N 2790 7905 2925 7905 { lab=Vg}
N 1995 7800 2145 7800 { lab=VLX}
N 2035 7905 2185 7905 { lab=Vg}
N 1995 7860 2145 7860 { lab=Vout}
N 3530 7740 3530 7830 { lab=Vg}
N 405 7635 650 7635 { lab=VLX}
N 400 7800 650 7800 { lab=VLX}
N 400 7635 400 7800 { lab=VLX}
N 400 7635 405 7635 { lab=VLX}
N 520 7695 650 7695 { lab=Vout}
N 520 7695 520 7905 { lab=Vout}
N 650 7985 785 7985 { lab=VLX}
N 785 7985 935 7985 { lab=VLX}
N 935 7985 1095 7985 { lab=VLX}
N 1095 7985 1255 7985 { lab=VLX}
N 650 8045 785 8045 { lab=Vout}
N 785 8045 935 8045 { lab=Vout}
N 935 8045 1095 8045 { lab=Vout}
N 1095 8045 1255 8045 { lab=Vout}
N 690 8015 690 8090 { lab=Vg}
N 690 8090 825 8090 { lab=Vg}
N 825 8015 825 8090 { lab=Vg}
N 825 8090 980 8090 { lab=Vg}
N 1295 8015 1295 8090 { lab=Vg}
N 980 8090 1295 8090 { lab=Vg}
N 975 8015 975 8090 { lab=Vg}
N 1135 8015 1135 8090 { lab=Vg}
N 650 7985 650 8015 { lab=VLX}
N 785 7985 785 8015 { lab=VLX}
N 935 7985 935 8015 { lab=VLX}
N 1095 7985 1095 8015 { lab=VLX}
N 1255 7985 1255 8015 { lab=VLX}
N 1390 7985 1525 7985 { lab=VLX}
N 1525 7985 1675 7985 { lab=VLX}
N 1675 7985 1835 7985 { lab=VLX}
N 1835 7985 1995 7985 { lab=VLX}
N 1390 8045 1525 8045 { lab=Vout}
N 1525 8045 1675 8045 { lab=Vout}
N 1675 8045 1835 8045 { lab=Vout}
N 1835 8045 1995 8045 { lab=Vout}
N 1430 8015 1430 8090 { lab=Vg}
N 1430 8090 1565 8090 { lab=Vg}
N 1565 8015 1565 8090 { lab=Vg}
N 1565 8090 1720 8090 { lab=Vg}
N 2035 8015 2035 8090 { lab=Vg}
N 1720 8090 2035 8090 { lab=Vg}
N 1715 8015 1715 8090 { lab=Vg}
N 1875 8015 1875 8090 { lab=Vg}
N 1390 7985 1390 8015 { lab=VLX}
N 1525 7985 1525 8015 { lab=VLX}
N 1675 7985 1675 8015 { lab=VLX}
N 1835 7985 1835 8015 { lab=VLX}
N 1995 7985 1995 8015 { lab=VLX}
N 1255 7985 1390 7985 { lab=VLX}
N 1255 8045 1390 8045 { lab=Vout}
N 1295 8090 1430 8090 { lab=Vg}
N 2145 7985 2280 7985 { lab=VLX}
N 2280 7985 2430 7985 { lab=VLX}
N 2430 7985 2590 7985 { lab=VLX}
N 2590 7985 2750 7985 { lab=VLX}
N 2145 8045 2280 8045 { lab=Vout}
N 2280 8045 2430 8045 { lab=Vout}
N 2430 8045 2590 8045 { lab=Vout}
N 2590 8045 2750 8045 { lab=Vout}
N 2185 8015 2185 8090 { lab=Vg}
N 2185 8090 2320 8090 { lab=Vg}
N 2320 8015 2320 8090 { lab=Vg}
N 2320 8090 2475 8090 { lab=Vg}
N 2790 8015 2790 8090 { lab=Vg}
N 2475 8090 2790 8090 { lab=Vg}
N 2470 8015 2470 8090 { lab=Vg}
N 2630 8015 2630 8090 { lab=Vg}
N 2145 7985 2145 8015 { lab=VLX}
N 2280 7985 2280 8015 { lab=VLX}
N 2430 7985 2430 8015 { lab=VLX}
N 2590 7985 2590 8015 { lab=VLX}
N 2750 7985 2750 8015 { lab=VLX}
N 2885 7985 3020 7985 { lab=VLX}
N 3020 7985 3170 7985 { lab=VLX}
N 3170 7985 3330 7985 { lab=VLX}
N 3330 7985 3490 7985 { lab=VLX}
N 2885 8045 3020 8045 { lab=Vout}
N 3020 8045 3170 8045 { lab=Vout}
N 3170 8045 3330 8045 { lab=Vout}
N 3330 8045 3490 8045 { lab=Vout}
N 2925 8015 2925 8090 { lab=Vg}
N 2925 8090 3060 8090 { lab=Vg}
N 3060 8015 3060 8090 { lab=Vg}
N 3060 8090 3215 8090 { lab=Vg}
N 3530 8015 3530 8090 { lab=Vg}
N 3215 8090 3530 8090 { lab=Vg}
N 3210 8015 3210 8090 { lab=Vg}
N 3370 8015 3370 8090 { lab=Vg}
N 2885 7985 2885 8015 { lab=VLX}
N 3020 7985 3020 8015 { lab=VLX}
N 3170 7985 3170 8015 { lab=VLX}
N 3330 7985 3330 8015 { lab=VLX}
N 3490 7985 3490 8015 { lab=VLX}
N 2750 7985 2885 7985 { lab=VLX}
N 2750 8045 2885 8045 { lab=Vout}
N 2790 8090 2925 8090 { lab=Vg}
N 1995 7985 2145 7985 { lab=VLX}
N 2035 8090 2185 8090 { lab=Vg}
N 1995 8045 2145 8045 { lab=Vout}
N 650 8150 785 8150 { lab=VLX}
N 785 8150 935 8150 { lab=VLX}
N 935 8150 1095 8150 { lab=VLX}
N 1095 8150 1255 8150 { lab=VLX}
N 650 8210 785 8210 { lab=Vout}
N 785 8210 935 8210 { lab=Vout}
N 935 8210 1095 8210 { lab=Vout}
N 1095 8210 1255 8210 { lab=Vout}
N 690 8180 690 8255 { lab=Vg}
N 690 8255 825 8255 { lab=Vg}
N 825 8180 825 8255 { lab=Vg}
N 825 8255 980 8255 { lab=Vg}
N 1295 8180 1295 8255 { lab=Vg}
N 980 8255 1295 8255 { lab=Vg}
N 975 8180 975 8255 { lab=Vg}
N 1135 8180 1135 8255 { lab=Vg}
N 650 8150 650 8180 { lab=VLX}
N 785 8150 785 8180 { lab=VLX}
N 935 8150 935 8180 { lab=VLX}
N 1095 8150 1095 8180 { lab=VLX}
N 1255 8150 1255 8180 { lab=VLX}
N 1390 8150 1525 8150 { lab=VLX}
N 1525 8150 1675 8150 { lab=VLX}
N 1675 8150 1835 8150 { lab=VLX}
N 1835 8150 1995 8150 { lab=VLX}
N 1390 8210 1525 8210 { lab=Vout}
N 1525 8210 1675 8210 { lab=Vout}
N 1675 8210 1835 8210 { lab=Vout}
N 1835 8210 1995 8210 { lab=Vout}
N 1430 8180 1430 8255 { lab=Vg}
N 1430 8255 1565 8255 { lab=Vg}
N 1565 8180 1565 8255 { lab=Vg}
N 1565 8255 1720 8255 { lab=Vg}
N 2035 8180 2035 8255 { lab=Vg}
N 1720 8255 2035 8255 { lab=Vg}
N 1715 8180 1715 8255 { lab=Vg}
N 1875 8180 1875 8255 { lab=Vg}
N 1390 8150 1390 8180 { lab=VLX}
N 1525 8150 1525 8180 { lab=VLX}
N 1675 8150 1675 8180 { lab=VLX}
N 1835 8150 1835 8180 { lab=VLX}
N 1995 8150 1995 8180 { lab=VLX}
N 1255 8150 1390 8150 { lab=VLX}
N 1255 8210 1390 8210 { lab=Vout}
N 1295 8255 1430 8255 { lab=Vg}
N 2145 8150 2280 8150 { lab=VLX}
N 2280 8150 2430 8150 { lab=VLX}
N 2430 8150 2590 8150 { lab=VLX}
N 2590 8150 2750 8150 { lab=VLX}
N 2145 8210 2280 8210 { lab=Vout}
N 2280 8210 2430 8210 { lab=Vout}
N 2430 8210 2590 8210 { lab=Vout}
N 2590 8210 2750 8210 { lab=Vout}
N 2185 8180 2185 8255 { lab=Vg}
N 2185 8255 2320 8255 { lab=Vg}
N 2320 8180 2320 8255 { lab=Vg}
N 2320 8255 2475 8255 { lab=Vg}
N 2790 8180 2790 8255 { lab=Vg}
N 2475 8255 2790 8255 { lab=Vg}
N 2470 8180 2470 8255 { lab=Vg}
N 2630 8180 2630 8255 { lab=Vg}
N 2145 8150 2145 8180 { lab=VLX}
N 2280 8150 2280 8180 { lab=VLX}
N 2430 8150 2430 8180 { lab=VLX}
N 2590 8150 2590 8180 { lab=VLX}
N 2750 8150 2750 8180 { lab=VLX}
N 2885 8150 3020 8150 { lab=VLX}
N 3020 8150 3170 8150 { lab=VLX}
N 3170 8150 3330 8150 { lab=VLX}
N 3330 8150 3490 8150 { lab=VLX}
N 2885 8210 3020 8210 { lab=Vout}
N 3020 8210 3170 8210 { lab=Vout}
N 3170 8210 3330 8210 { lab=Vout}
N 3330 8210 3490 8210 { lab=Vout}
N 2925 8180 2925 8255 { lab=Vg}
N 2925 8255 3060 8255 { lab=Vg}
N 3060 8180 3060 8255 { lab=Vg}
N 3060 8255 3215 8255 { lab=Vg}
N 3530 8180 3530 8255 { lab=Vg}
N 3215 8255 3530 8255 { lab=Vg}
N 3210 8180 3210 8255 { lab=Vg}
N 3370 8180 3370 8255 { lab=Vg}
N 2885 8150 2885 8180 { lab=VLX}
N 3020 8150 3020 8180 { lab=VLX}
N 3170 8150 3170 8180 { lab=VLX}
N 3330 8150 3330 8180 { lab=VLX}
N 3490 8150 3490 8180 { lab=VLX}
N 2750 8150 2885 8150 { lab=VLX}
N 2750 8210 2885 8210 { lab=Vout}
N 2790 8255 2925 8255 { lab=Vg}
N 1995 8150 2145 8150 { lab=VLX}
N 2035 8255 2185 8255 { lab=Vg}
N 1995 8210 2145 8210 { lab=Vout}
N 3530 8090 3530 8180 { lab=Vg}
N 405 7985 650 7985 { lab=VLX}
N 400 8150 650 8150 { lab=VLX}
N 400 7985 400 8150 { lab=VLX}
N 400 7985 405 7985 { lab=VLX}
N 520 8045 650 8045 { lab=Vout}
N 520 8045 520 8255 { lab=Vout}
N 400 7800 400 7990 { lab=VLX}
N 520 7900 520 8050 { lab=Vout}
N 3530 7900 3530 8020 { lab=Vg}
N 650 8305 785 8305 { lab=VLX}
N 785 8305 935 8305 { lab=VLX}
N 935 8305 1095 8305 { lab=VLX}
N 1095 8305 1255 8305 { lab=VLX}
N 650 8365 785 8365 { lab=Vout}
N 785 8365 935 8365 { lab=Vout}
N 935 8365 1095 8365 { lab=Vout}
N 1095 8365 1255 8365 { lab=Vout}
N 690 8335 690 8410 { lab=Vg}
N 690 8410 825 8410 { lab=Vg}
N 825 8335 825 8410 { lab=Vg}
N 825 8410 980 8410 { lab=Vg}
N 1295 8335 1295 8410 { lab=Vg}
N 980 8410 1295 8410 { lab=Vg}
N 975 8335 975 8410 { lab=Vg}
N 1135 8335 1135 8410 { lab=Vg}
N 650 8305 650 8335 { lab=VLX}
N 785 8305 785 8335 { lab=VLX}
N 935 8305 935 8335 { lab=VLX}
N 1095 8305 1095 8335 { lab=VLX}
N 1255 8305 1255 8335 { lab=VLX}
N 1390 8305 1525 8305 { lab=VLX}
N 1525 8305 1675 8305 { lab=VLX}
N 1675 8305 1835 8305 { lab=VLX}
N 1835 8305 1995 8305 { lab=VLX}
N 1390 8365 1525 8365 { lab=Vout}
N 1525 8365 1675 8365 { lab=Vout}
N 1675 8365 1835 8365 { lab=Vout}
N 1835 8365 1995 8365 { lab=Vout}
N 1430 8335 1430 8410 { lab=Vg}
N 1430 8410 1565 8410 { lab=Vg}
N 1565 8335 1565 8410 { lab=Vg}
N 1565 8410 1720 8410 { lab=Vg}
N 2035 8335 2035 8410 { lab=Vg}
N 1720 8410 2035 8410 { lab=Vg}
N 1715 8335 1715 8410 { lab=Vg}
N 1875 8335 1875 8410 { lab=Vg}
N 1390 8305 1390 8335 { lab=VLX}
N 1525 8305 1525 8335 { lab=VLX}
N 1675 8305 1675 8335 { lab=VLX}
N 1835 8305 1835 8335 { lab=VLX}
N 1995 8305 1995 8335 { lab=VLX}
N 1255 8305 1390 8305 { lab=VLX}
N 1255 8365 1390 8365 { lab=Vout}
N 1295 8410 1430 8410 { lab=Vg}
N 2145 8305 2280 8305 { lab=VLX}
N 2280 8305 2430 8305 { lab=VLX}
N 2430 8305 2590 8305 { lab=VLX}
N 2590 8305 2750 8305 { lab=VLX}
N 2145 8365 2280 8365 { lab=Vout}
N 2280 8365 2430 8365 { lab=Vout}
N 2430 8365 2590 8365 { lab=Vout}
N 2590 8365 2750 8365 { lab=Vout}
N 2185 8335 2185 8410 { lab=Vg}
N 2185 8410 2320 8410 { lab=Vg}
N 2320 8335 2320 8410 { lab=Vg}
N 2320 8410 2475 8410 { lab=Vg}
N 2790 8335 2790 8410 { lab=Vg}
N 2475 8410 2790 8410 { lab=Vg}
N 2470 8335 2470 8410 { lab=Vg}
N 2630 8335 2630 8410 { lab=Vg}
N 2145 8305 2145 8335 { lab=VLX}
N 2280 8305 2280 8335 { lab=VLX}
N 2430 8305 2430 8335 { lab=VLX}
N 2590 8305 2590 8335 { lab=VLX}
N 2750 8305 2750 8335 { lab=VLX}
N 2885 8305 3020 8305 { lab=VLX}
N 3020 8305 3170 8305 { lab=VLX}
N 3170 8305 3330 8305 { lab=VLX}
N 3330 8305 3490 8305 { lab=VLX}
N 2885 8365 3020 8365 { lab=Vout}
N 3020 8365 3170 8365 { lab=Vout}
N 3170 8365 3330 8365 { lab=Vout}
N 3330 8365 3490 8365 { lab=Vout}
N 2925 8335 2925 8410 { lab=Vg}
N 2925 8410 3060 8410 { lab=Vg}
N 3060 8335 3060 8410 { lab=Vg}
N 3060 8410 3215 8410 { lab=Vg}
N 3530 8335 3530 8410 { lab=Vg}
N 3215 8410 3530 8410 { lab=Vg}
N 3210 8335 3210 8410 { lab=Vg}
N 3370 8335 3370 8410 { lab=Vg}
N 2885 8305 2885 8335 { lab=VLX}
N 3020 8305 3020 8335 { lab=VLX}
N 3170 8305 3170 8335 { lab=VLX}
N 3330 8305 3330 8335 { lab=VLX}
N 3490 8305 3490 8335 { lab=VLX}
N 2750 8305 2885 8305 { lab=VLX}
N 2750 8365 2885 8365 { lab=Vout}
N 2790 8410 2925 8410 { lab=Vg}
N 1995 8305 2145 8305 { lab=VLX}
N 2035 8410 2185 8410 { lab=Vg}
N 1995 8365 2145 8365 { lab=Vout}
N 650 8470 785 8470 { lab=VLX}
N 785 8470 935 8470 { lab=VLX}
N 935 8470 1095 8470 { lab=VLX}
N 1095 8470 1255 8470 { lab=VLX}
N 650 8530 785 8530 { lab=Vout}
N 785 8530 935 8530 { lab=Vout}
N 935 8530 1095 8530 { lab=Vout}
N 1095 8530 1255 8530 { lab=Vout}
N 690 8500 690 8575 { lab=Vg}
N 690 8575 825 8575 { lab=Vg}
N 825 8500 825 8575 { lab=Vg}
N 825 8575 980 8575 { lab=Vg}
N 1295 8500 1295 8575 { lab=Vg}
N 980 8575 1295 8575 { lab=Vg}
N 975 8500 975 8575 { lab=Vg}
N 1135 8500 1135 8575 { lab=Vg}
N 650 8470 650 8500 { lab=VLX}
N 785 8470 785 8500 { lab=VLX}
N 935 8470 935 8500 { lab=VLX}
N 1095 8470 1095 8500 { lab=VLX}
N 1255 8470 1255 8500 { lab=VLX}
N 1390 8470 1525 8470 { lab=VLX}
N 1525 8470 1675 8470 { lab=VLX}
N 1675 8470 1835 8470 { lab=VLX}
N 1835 8470 1995 8470 { lab=VLX}
N 1390 8530 1525 8530 { lab=Vout}
N 1525 8530 1675 8530 { lab=Vout}
N 1675 8530 1835 8530 { lab=Vout}
N 1835 8530 1995 8530 { lab=Vout}
N 1430 8500 1430 8575 { lab=Vg}
N 1430 8575 1565 8575 { lab=Vg}
N 1565 8500 1565 8575 { lab=Vg}
N 1565 8575 1720 8575 { lab=Vg}
N 2035 8500 2035 8575 { lab=Vg}
N 1720 8575 2035 8575 { lab=Vg}
N 1715 8500 1715 8575 { lab=Vg}
N 1875 8500 1875 8575 { lab=Vg}
N 1390 8470 1390 8500 { lab=VLX}
N 1525 8470 1525 8500 { lab=VLX}
N 1675 8470 1675 8500 { lab=VLX}
N 1835 8470 1835 8500 { lab=VLX}
N 1995 8470 1995 8500 { lab=VLX}
N 1255 8470 1390 8470 { lab=VLX}
N 1255 8530 1390 8530 { lab=Vout}
N 1295 8575 1430 8575 { lab=Vg}
N 2145 8470 2280 8470 { lab=VLX}
N 2280 8470 2430 8470 { lab=VLX}
N 2430 8470 2590 8470 { lab=VLX}
N 2590 8470 2750 8470 { lab=VLX}
N 2145 8530 2280 8530 { lab=Vout}
N 2280 8530 2430 8530 { lab=Vout}
N 2430 8530 2590 8530 { lab=Vout}
N 2590 8530 2750 8530 { lab=Vout}
N 2185 8500 2185 8575 { lab=Vg}
N 2185 8575 2320 8575 { lab=Vg}
N 2320 8500 2320 8575 { lab=Vg}
N 2320 8575 2475 8575 { lab=Vg}
N 2790 8500 2790 8575 { lab=Vg}
N 2475 8575 2790 8575 { lab=Vg}
N 2470 8500 2470 8575 { lab=Vg}
N 2630 8500 2630 8575 { lab=Vg}
N 2145 8470 2145 8500 { lab=VLX}
N 2280 8470 2280 8500 { lab=VLX}
N 2430 8470 2430 8500 { lab=VLX}
N 2590 8470 2590 8500 { lab=VLX}
N 2750 8470 2750 8500 { lab=VLX}
N 2885 8470 3020 8470 { lab=VLX}
N 3020 8470 3170 8470 { lab=VLX}
N 3170 8470 3330 8470 { lab=VLX}
N 3330 8470 3490 8470 { lab=VLX}
N 2885 8530 3020 8530 { lab=Vout}
N 3020 8530 3170 8530 { lab=Vout}
N 3170 8530 3330 8530 { lab=Vout}
N 3330 8530 3490 8530 { lab=Vout}
N 2925 8500 2925 8575 { lab=Vg}
N 2925 8575 3060 8575 { lab=Vg}
N 3060 8500 3060 8575 { lab=Vg}
N 3060 8575 3215 8575 { lab=Vg}
N 3530 8500 3530 8575 { lab=Vg}
N 3215 8575 3530 8575 { lab=Vg}
N 3210 8500 3210 8575 { lab=Vg}
N 3370 8500 3370 8575 { lab=Vg}
N 2885 8470 2885 8500 { lab=VLX}
N 3020 8470 3020 8500 { lab=VLX}
N 3170 8470 3170 8500 { lab=VLX}
N 3330 8470 3330 8500 { lab=VLX}
N 3490 8470 3490 8500 { lab=VLX}
N 2750 8470 2885 8470 { lab=VLX}
N 2750 8530 2885 8530 { lab=Vout}
N 2790 8575 2925 8575 { lab=Vg}
N 1995 8470 2145 8470 { lab=VLX}
N 2035 8575 2185 8575 { lab=Vg}
N 1995 8530 2145 8530 { lab=Vout}
N 3530 8410 3530 8500 { lab=Vg}
N 405 8305 650 8305 { lab=VLX}
N 400 8470 650 8470 { lab=VLX}
N 400 8305 400 8470 { lab=VLX}
N 400 8305 405 8305 { lab=VLX}
N 520 8365 650 8365 { lab=Vout}
N 520 8365 520 8575 { lab=Vout}
N 650 8655 785 8655 { lab=VLX}
N 785 8655 935 8655 { lab=VLX}
N 935 8655 1095 8655 { lab=VLX}
N 1095 8655 1255 8655 { lab=VLX}
N 650 8715 785 8715 { lab=Vout}
N 785 8715 935 8715 { lab=Vout}
N 935 8715 1095 8715 { lab=Vout}
N 1095 8715 1255 8715 { lab=Vout}
N 690 8685 690 8760 { lab=Vg}
N 690 8760 825 8760 { lab=Vg}
N 825 8685 825 8760 { lab=Vg}
N 825 8760 980 8760 { lab=Vg}
N 1295 8685 1295 8760 { lab=Vg}
N 980 8760 1295 8760 { lab=Vg}
N 975 8685 975 8760 { lab=Vg}
N 1135 8685 1135 8760 { lab=Vg}
N 650 8655 650 8685 { lab=VLX}
N 785 8655 785 8685 { lab=VLX}
N 935 8655 935 8685 { lab=VLX}
N 1095 8655 1095 8685 { lab=VLX}
N 1255 8655 1255 8685 { lab=VLX}
N 1390 8655 1525 8655 { lab=VLX}
N 1525 8655 1675 8655 { lab=VLX}
N 1675 8655 1835 8655 { lab=VLX}
N 1835 8655 1995 8655 { lab=VLX}
N 1390 8715 1525 8715 { lab=Vout}
N 1525 8715 1675 8715 { lab=Vout}
N 1675 8715 1835 8715 { lab=Vout}
N 1835 8715 1995 8715 { lab=Vout}
N 1430 8685 1430 8760 { lab=Vg}
N 1430 8760 1565 8760 { lab=Vg}
N 1565 8685 1565 8760 { lab=Vg}
N 1565 8760 1720 8760 { lab=Vg}
N 2035 8685 2035 8760 { lab=Vg}
N 1720 8760 2035 8760 { lab=Vg}
N 1715 8685 1715 8760 { lab=Vg}
N 1875 8685 1875 8760 { lab=Vg}
N 1390 8655 1390 8685 { lab=VLX}
N 1525 8655 1525 8685 { lab=VLX}
N 1675 8655 1675 8685 { lab=VLX}
N 1835 8655 1835 8685 { lab=VLX}
N 1995 8655 1995 8685 { lab=VLX}
N 1255 8655 1390 8655 { lab=VLX}
N 1255 8715 1390 8715 { lab=Vout}
N 1295 8760 1430 8760 { lab=Vg}
N 2145 8655 2280 8655 { lab=VLX}
N 2280 8655 2430 8655 { lab=VLX}
N 2430 8655 2590 8655 { lab=VLX}
N 2590 8655 2750 8655 { lab=VLX}
N 2145 8715 2280 8715 { lab=Vout}
N 2280 8715 2430 8715 { lab=Vout}
N 2430 8715 2590 8715 { lab=Vout}
N 2590 8715 2750 8715 { lab=Vout}
N 2185 8685 2185 8760 { lab=Vg}
N 2185 8760 2320 8760 { lab=Vg}
N 2320 8685 2320 8760 { lab=Vg}
N 2320 8760 2475 8760 { lab=Vg}
N 2790 8685 2790 8760 { lab=Vg}
N 2475 8760 2790 8760 { lab=Vg}
N 2470 8685 2470 8760 { lab=Vg}
N 2630 8685 2630 8760 { lab=Vg}
N 2145 8655 2145 8685 { lab=VLX}
N 2280 8655 2280 8685 { lab=VLX}
N 2430 8655 2430 8685 { lab=VLX}
N 2590 8655 2590 8685 { lab=VLX}
N 2750 8655 2750 8685 { lab=VLX}
N 2885 8655 3020 8655 { lab=VLX}
N 3020 8655 3170 8655 { lab=VLX}
N 3170 8655 3330 8655 { lab=VLX}
N 3330 8655 3490 8655 { lab=VLX}
N 2885 8715 3020 8715 { lab=Vout}
N 3020 8715 3170 8715 { lab=Vout}
N 3170 8715 3330 8715 { lab=Vout}
N 3330 8715 3490 8715 { lab=Vout}
N 2925 8685 2925 8760 { lab=Vg}
N 2925 8760 3060 8760 { lab=Vg}
N 3060 8685 3060 8760 { lab=Vg}
N 3060 8760 3215 8760 { lab=Vg}
N 3530 8685 3530 8760 { lab=Vg}
N 3215 8760 3530 8760 { lab=Vg}
N 3210 8685 3210 8760 { lab=Vg}
N 3370 8685 3370 8760 { lab=Vg}
N 2885 8655 2885 8685 { lab=VLX}
N 3020 8655 3020 8685 { lab=VLX}
N 3170 8655 3170 8685 { lab=VLX}
N 3330 8655 3330 8685 { lab=VLX}
N 3490 8655 3490 8685 { lab=VLX}
N 2750 8655 2885 8655 { lab=VLX}
N 2750 8715 2885 8715 { lab=Vout}
N 2790 8760 2925 8760 { lab=Vg}
N 1995 8655 2145 8655 { lab=VLX}
N 2035 8760 2185 8760 { lab=Vg}
N 1995 8715 2145 8715 { lab=Vout}
N 650 8820 785 8820 { lab=VLX}
N 785 8820 935 8820 { lab=VLX}
N 935 8820 1095 8820 { lab=VLX}
N 1095 8820 1255 8820 { lab=VLX}
N 650 8880 785 8880 { lab=Vout}
N 785 8880 935 8880 { lab=Vout}
N 935 8880 1095 8880 { lab=Vout}
N 1095 8880 1255 8880 { lab=Vout}
N 690 8850 690 8925 { lab=Vg}
N 690 8925 825 8925 { lab=Vg}
N 825 8850 825 8925 { lab=Vg}
N 825 8925 980 8925 { lab=Vg}
N 1295 8850 1295 8925 { lab=Vg}
N 980 8925 1295 8925 { lab=Vg}
N 975 8850 975 8925 { lab=Vg}
N 1135 8850 1135 8925 { lab=Vg}
N 650 8820 650 8850 { lab=VLX}
N 785 8820 785 8850 { lab=VLX}
N 935 8820 935 8850 { lab=VLX}
N 1095 8820 1095 8850 { lab=VLX}
N 1255 8820 1255 8850 { lab=VLX}
N 1390 8820 1525 8820 { lab=VLX}
N 1525 8820 1675 8820 { lab=VLX}
N 1675 8820 1835 8820 { lab=VLX}
N 1835 8820 1995 8820 { lab=VLX}
N 1390 8880 1525 8880 { lab=Vout}
N 1525 8880 1675 8880 { lab=Vout}
N 1675 8880 1835 8880 { lab=Vout}
N 1835 8880 1995 8880 { lab=Vout}
N 1430 8850 1430 8925 { lab=Vg}
N 1430 8925 1565 8925 { lab=Vg}
N 1565 8850 1565 8925 { lab=Vg}
N 1565 8925 1720 8925 { lab=Vg}
N 2035 8850 2035 8925 { lab=Vg}
N 1720 8925 2035 8925 { lab=Vg}
N 1715 8850 1715 8925 { lab=Vg}
N 1875 8850 1875 8925 { lab=Vg}
N 1390 8820 1390 8850 { lab=VLX}
N 1525 8820 1525 8850 { lab=VLX}
N 1675 8820 1675 8850 { lab=VLX}
N 1835 8820 1835 8850 { lab=VLX}
N 1995 8820 1995 8850 { lab=VLX}
N 1255 8820 1390 8820 { lab=VLX}
N 1255 8880 1390 8880 { lab=Vout}
N 1295 8925 1430 8925 { lab=Vg}
N 2145 8820 2280 8820 { lab=VLX}
N 2280 8820 2430 8820 { lab=VLX}
N 2430 8820 2590 8820 { lab=VLX}
N 2590 8820 2750 8820 { lab=VLX}
N 2145 8880 2280 8880 { lab=Vout}
N 2280 8880 2430 8880 { lab=Vout}
N 2430 8880 2590 8880 { lab=Vout}
N 2590 8880 2750 8880 { lab=Vout}
N 2185 8850 2185 8925 { lab=Vg}
N 2185 8925 2320 8925 { lab=Vg}
N 2320 8850 2320 8925 { lab=Vg}
N 2320 8925 2475 8925 { lab=Vg}
N 2790 8850 2790 8925 { lab=Vg}
N 2475 8925 2790 8925 { lab=Vg}
N 2470 8850 2470 8925 { lab=Vg}
N 2630 8850 2630 8925 { lab=Vg}
N 2145 8820 2145 8850 { lab=VLX}
N 2280 8820 2280 8850 { lab=VLX}
N 2430 8820 2430 8850 { lab=VLX}
N 2590 8820 2590 8850 { lab=VLX}
N 2750 8820 2750 8850 { lab=VLX}
N 2885 8820 3020 8820 { lab=VLX}
N 3020 8820 3170 8820 { lab=VLX}
N 3170 8820 3330 8820 { lab=VLX}
N 3330 8820 3490 8820 { lab=VLX}
N 2885 8880 3020 8880 { lab=Vout}
N 3020 8880 3170 8880 { lab=Vout}
N 3170 8880 3330 8880 { lab=Vout}
N 3330 8880 3490 8880 { lab=Vout}
N 2925 8850 2925 8925 { lab=Vg}
N 2925 8925 3060 8925 { lab=Vg}
N 3060 8850 3060 8925 { lab=Vg}
N 3060 8925 3215 8925 { lab=Vg}
N 3530 8850 3530 8925 { lab=Vg}
N 3215 8925 3530 8925 { lab=Vg}
N 3210 8850 3210 8925 { lab=Vg}
N 3370 8850 3370 8925 { lab=Vg}
N 2885 8820 2885 8850 { lab=VLX}
N 3020 8820 3020 8850 { lab=VLX}
N 3170 8820 3170 8850 { lab=VLX}
N 3330 8820 3330 8850 { lab=VLX}
N 3490 8820 3490 8850 { lab=VLX}
N 2750 8820 2885 8820 { lab=VLX}
N 2750 8880 2885 8880 { lab=Vout}
N 2790 8925 2925 8925 { lab=Vg}
N 1995 8820 2145 8820 { lab=VLX}
N 2035 8925 2185 8925 { lab=Vg}
N 1995 8880 2145 8880 { lab=Vout}
N 3530 8760 3530 8850 { lab=Vg}
N 405 8655 650 8655 { lab=VLX}
N 400 8820 650 8820 { lab=VLX}
N 400 8655 400 8820 { lab=VLX}
N 400 8655 405 8655 { lab=VLX}
N 520 8715 650 8715 { lab=Vout}
N 520 8715 520 8925 { lab=Vout}
N 400 8470 400 8660 { lab=VLX}
N 520 8570 520 8720 { lab=Vout}
N 3530 8570 3530 8690 { lab=Vg}
N 400 8150 400 8310 { lab=VLX}
N 520 8250 520 8370 { lab=Vout}
N 3530 8260 3530 8330 { lab=Vg}
N 3530 8250 3530 8260 { lab=Vg}
N 3530 7500 3530 7670 { lab=Vg}
N 520 7500 520 7710 { lab=Vout}
N 400 7400 400 7640 { lab=VLX}
N 3530 6060 3530 6250 { lab=Vg}
N 520 6050 520 6280 { lab=Vout}
N 400 5960 400 6220 { lab=VLX}
N 700 9185 835 9185 { lab=VLX}
N 835 9185 985 9185 { lab=VLX}
N 985 9185 1145 9185 { lab=VLX}
N 1145 9185 1305 9185 { lab=VLX}
N 700 9245 835 9245 { lab=Vout}
N 835 9245 985 9245 { lab=Vout}
N 985 9245 1145 9245 { lab=Vout}
N 1145 9245 1305 9245 { lab=Vout}
N 740 9215 740 9290 { lab=Vg}
N 740 9290 875 9290 { lab=Vg}
N 875 9215 875 9290 { lab=Vg}
N 875 9290 1030 9290 { lab=Vg}
N 1345 9215 1345 9290 { lab=Vg}
N 1030 9290 1345 9290 { lab=Vg}
N 1025 9215 1025 9290 { lab=Vg}
N 1185 9215 1185 9290 { lab=Vg}
N 700 9185 700 9215 { lab=VLX}
N 835 9185 835 9215 { lab=VLX}
N 985 9185 985 9215 { lab=VLX}
N 1145 9185 1145 9215 { lab=VLX}
N 1305 9185 1305 9215 { lab=VLX}
N 1440 9185 1575 9185 { lab=VLX}
N 1575 9185 1725 9185 { lab=VLX}
N 1725 9185 1885 9185 { lab=VLX}
N 1885 9185 2045 9185 { lab=VLX}
N 1440 9245 1575 9245 { lab=Vout}
N 1575 9245 1725 9245 { lab=Vout}
N 1725 9245 1885 9245 { lab=Vout}
N 1885 9245 2045 9245 { lab=Vout}
N 1480 9215 1480 9290 { lab=Vg}
N 1480 9290 1615 9290 { lab=Vg}
N 1615 9215 1615 9290 { lab=Vg}
N 1615 9290 1770 9290 { lab=Vg}
N 2085 9215 2085 9290 { lab=Vg}
N 1770 9290 2085 9290 { lab=Vg}
N 1765 9215 1765 9290 { lab=Vg}
N 1925 9215 1925 9290 { lab=Vg}
N 1440 9185 1440 9215 { lab=VLX}
N 1575 9185 1575 9215 { lab=VLX}
N 1725 9185 1725 9215 { lab=VLX}
N 1885 9185 1885 9215 { lab=VLX}
N 2045 9185 2045 9215 { lab=VLX}
N 1305 9185 1440 9185 { lab=VLX}
N 1305 9245 1440 9245 { lab=Vout}
N 1345 9290 1480 9290 { lab=Vg}
N 2195 9185 2330 9185 { lab=VLX}
N 2330 9185 2480 9185 { lab=VLX}
N 2480 9185 2640 9185 { lab=VLX}
N 2640 9185 2800 9185 { lab=VLX}
N 2195 9245 2330 9245 { lab=Vout}
N 2330 9245 2480 9245 { lab=Vout}
N 2480 9245 2640 9245 { lab=Vout}
N 2640 9245 2800 9245 { lab=Vout}
N 2235 9215 2235 9290 { lab=Vg}
N 2235 9290 2370 9290 { lab=Vg}
N 2370 9215 2370 9290 { lab=Vg}
N 2370 9290 2525 9290 { lab=Vg}
N 2840 9215 2840 9290 { lab=Vg}
N 2525 9290 2840 9290 { lab=Vg}
N 2520 9215 2520 9290 { lab=Vg}
N 2680 9215 2680 9290 { lab=Vg}
N 2195 9185 2195 9215 { lab=VLX}
N 2330 9185 2330 9215 { lab=VLX}
N 2480 9185 2480 9215 { lab=VLX}
N 2640 9185 2640 9215 { lab=VLX}
N 2800 9185 2800 9215 { lab=VLX}
N 2935 9185 3070 9185 { lab=VLX}
N 3070 9185 3220 9185 { lab=VLX}
N 3220 9185 3380 9185 { lab=VLX}
N 3380 9185 3540 9185 { lab=VLX}
N 2935 9245 3070 9245 { lab=Vout}
N 3070 9245 3220 9245 { lab=Vout}
N 3220 9245 3380 9245 { lab=Vout}
N 3380 9245 3540 9245 { lab=Vout}
N 2975 9215 2975 9290 { lab=Vg}
N 2975 9290 3110 9290 { lab=Vg}
N 3110 9215 3110 9290 { lab=Vg}
N 3110 9290 3265 9290 { lab=Vg}
N 3580 9215 3580 9290 { lab=Vg}
N 3265 9290 3580 9290 { lab=Vg}
N 3260 9215 3260 9290 { lab=Vg}
N 3420 9215 3420 9290 { lab=Vg}
N 2935 9185 2935 9215 { lab=VLX}
N 3070 9185 3070 9215 { lab=VLX}
N 3220 9185 3220 9215 { lab=VLX}
N 3380 9185 3380 9215 { lab=VLX}
N 3540 9185 3540 9215 { lab=VLX}
N 2800 9185 2935 9185 { lab=VLX}
N 2800 9245 2935 9245 { lab=Vout}
N 2840 9290 2975 9290 { lab=Vg}
N 2045 9185 2195 9185 { lab=VLX}
N 2085 9290 2235 9290 { lab=Vg}
N 2045 9245 2195 9245 { lab=Vout}
N 700 9350 835 9350 { lab=VLX}
N 835 9350 985 9350 { lab=VLX}
N 985 9350 1145 9350 { lab=VLX}
N 1145 9350 1305 9350 { lab=VLX}
N 700 9410 835 9410 { lab=Vout}
N 835 9410 985 9410 { lab=Vout}
N 985 9410 1145 9410 { lab=Vout}
N 1145 9410 1305 9410 { lab=Vout}
N 740 9380 740 9455 { lab=Vg}
N 740 9455 875 9455 { lab=Vg}
N 875 9380 875 9455 { lab=Vg}
N 875 9455 1030 9455 { lab=Vg}
N 1345 9380 1345 9455 { lab=Vg}
N 1030 9455 1345 9455 { lab=Vg}
N 1025 9380 1025 9455 { lab=Vg}
N 1185 9380 1185 9455 { lab=Vg}
N 700 9350 700 9380 { lab=VLX}
N 835 9350 835 9380 { lab=VLX}
N 985 9350 985 9380 { lab=VLX}
N 1145 9350 1145 9380 { lab=VLX}
N 1305 9350 1305 9380 { lab=VLX}
N 1440 9350 1575 9350 { lab=VLX}
N 1575 9350 1725 9350 { lab=VLX}
N 1725 9350 1885 9350 { lab=VLX}
N 1885 9350 2045 9350 { lab=VLX}
N 1440 9410 1575 9410 { lab=Vout}
N 1575 9410 1725 9410 { lab=Vout}
N 1725 9410 1885 9410 { lab=Vout}
N 1885 9410 2045 9410 { lab=Vout}
N 1480 9380 1480 9455 { lab=Vg}
N 1480 9455 1615 9455 { lab=Vg}
N 1615 9380 1615 9455 { lab=Vg}
N 1615 9455 1770 9455 { lab=Vg}
N 2085 9380 2085 9455 { lab=Vg}
N 1770 9455 2085 9455 { lab=Vg}
N 1765 9380 1765 9455 { lab=Vg}
N 1925 9380 1925 9455 { lab=Vg}
N 1440 9350 1440 9380 { lab=VLX}
N 1575 9350 1575 9380 { lab=VLX}
N 1725 9350 1725 9380 { lab=VLX}
N 1885 9350 1885 9380 { lab=VLX}
N 2045 9350 2045 9380 { lab=VLX}
N 1305 9350 1440 9350 { lab=VLX}
N 1305 9410 1440 9410 { lab=Vout}
N 1345 9455 1480 9455 { lab=Vg}
N 2195 9350 2330 9350 { lab=VLX}
N 2330 9350 2480 9350 { lab=VLX}
N 2480 9350 2640 9350 { lab=VLX}
N 2640 9350 2800 9350 { lab=VLX}
N 2195 9410 2330 9410 { lab=Vout}
N 2330 9410 2480 9410 { lab=Vout}
N 2480 9410 2640 9410 { lab=Vout}
N 2640 9410 2800 9410 { lab=Vout}
N 2235 9380 2235 9455 { lab=Vg}
N 2235 9455 2370 9455 { lab=Vg}
N 2370 9380 2370 9455 { lab=Vg}
N 2370 9455 2525 9455 { lab=Vg}
N 2840 9380 2840 9455 { lab=Vg}
N 2525 9455 2840 9455 { lab=Vg}
N 2520 9380 2520 9455 { lab=Vg}
N 2680 9380 2680 9455 { lab=Vg}
N 2195 9350 2195 9380 { lab=VLX}
N 2330 9350 2330 9380 { lab=VLX}
N 2480 9350 2480 9380 { lab=VLX}
N 2640 9350 2640 9380 { lab=VLX}
N 2800 9350 2800 9380 { lab=VLX}
N 2935 9350 3070 9350 { lab=VLX}
N 3070 9350 3220 9350 { lab=VLX}
N 3220 9350 3380 9350 { lab=VLX}
N 3380 9350 3540 9350 { lab=VLX}
N 2935 9410 3070 9410 { lab=Vout}
N 3070 9410 3220 9410 { lab=Vout}
N 3220 9410 3380 9410 { lab=Vout}
N 3380 9410 3540 9410 { lab=Vout}
N 2975 9380 2975 9455 { lab=Vg}
N 2975 9455 3110 9455 { lab=Vg}
N 3110 9380 3110 9455 { lab=Vg}
N 3110 9455 3265 9455 { lab=Vg}
N 3580 9380 3580 9455 { lab=Vg}
N 3265 9455 3580 9455 { lab=Vg}
N 3260 9380 3260 9455 { lab=Vg}
N 3420 9380 3420 9455 { lab=Vg}
N 2935 9350 2935 9380 { lab=VLX}
N 3070 9350 3070 9380 { lab=VLX}
N 3220 9350 3220 9380 { lab=VLX}
N 3380 9350 3380 9380 { lab=VLX}
N 3540 9350 3540 9380 { lab=VLX}
N 2800 9350 2935 9350 { lab=VLX}
N 2800 9410 2935 9410 { lab=Vout}
N 2840 9455 2975 9455 { lab=Vg}
N 2045 9350 2195 9350 { lab=VLX}
N 2085 9455 2235 9455 { lab=Vg}
N 2045 9410 2195 9410 { lab=Vout}
N 3580 9290 3580 9380 { lab=Vg}
N 455 9185 700 9185 { lab=VLX}
N 450 9350 700 9350 { lab=VLX}
N 450 9185 450 9350 { lab=VLX}
N 450 9185 455 9185 { lab=VLX}
N 570 9245 700 9245 { lab=Vout}
N 570 9245 570 9455 { lab=Vout}
N 700 9535 835 9535 { lab=VLX}
N 835 9535 985 9535 { lab=VLX}
N 985 9535 1145 9535 { lab=VLX}
N 1145 9535 1305 9535 { lab=VLX}
N 700 9595 835 9595 { lab=Vout}
N 835 9595 985 9595 { lab=Vout}
N 985 9595 1145 9595 { lab=Vout}
N 1145 9595 1305 9595 { lab=Vout}
N 740 9565 740 9640 { lab=Vg}
N 740 9640 875 9640 { lab=Vg}
N 875 9565 875 9640 { lab=Vg}
N 875 9640 1030 9640 { lab=Vg}
N 1345 9565 1345 9640 { lab=Vg}
N 1030 9640 1345 9640 { lab=Vg}
N 1025 9565 1025 9640 { lab=Vg}
N 1185 9565 1185 9640 { lab=Vg}
N 700 9535 700 9565 { lab=VLX}
N 835 9535 835 9565 { lab=VLX}
N 985 9535 985 9565 { lab=VLX}
N 1145 9535 1145 9565 { lab=VLX}
N 1305 9535 1305 9565 { lab=VLX}
N 1440 9535 1575 9535 { lab=VLX}
N 1575 9535 1725 9535 { lab=VLX}
N 1725 9535 1885 9535 { lab=VLX}
N 1885 9535 2045 9535 { lab=VLX}
N 1440 9595 1575 9595 { lab=Vout}
N 1575 9595 1725 9595 { lab=Vout}
N 1725 9595 1885 9595 { lab=Vout}
N 1885 9595 2045 9595 { lab=Vout}
N 1480 9565 1480 9640 { lab=Vg}
N 1480 9640 1615 9640 { lab=Vg}
N 1615 9565 1615 9640 { lab=Vg}
N 1615 9640 1770 9640 { lab=Vg}
N 2085 9565 2085 9640 { lab=Vg}
N 1770 9640 2085 9640 { lab=Vg}
N 1765 9565 1765 9640 { lab=Vg}
N 1925 9565 1925 9640 { lab=Vg}
N 1440 9535 1440 9565 { lab=VLX}
N 1575 9535 1575 9565 { lab=VLX}
N 1725 9535 1725 9565 { lab=VLX}
N 1885 9535 1885 9565 { lab=VLX}
N 2045 9535 2045 9565 { lab=VLX}
N 1305 9535 1440 9535 { lab=VLX}
N 1305 9595 1440 9595 { lab=Vout}
N 1345 9640 1480 9640 { lab=Vg}
N 2195 9535 2330 9535 { lab=VLX}
N 2330 9535 2480 9535 { lab=VLX}
N 2480 9535 2640 9535 { lab=VLX}
N 2640 9535 2800 9535 { lab=VLX}
N 2195 9595 2330 9595 { lab=Vout}
N 2330 9595 2480 9595 { lab=Vout}
N 2480 9595 2640 9595 { lab=Vout}
N 2640 9595 2800 9595 { lab=Vout}
N 2235 9565 2235 9640 { lab=Vg}
N 2235 9640 2370 9640 { lab=Vg}
N 2370 9565 2370 9640 { lab=Vg}
N 2370 9640 2525 9640 { lab=Vg}
N 2840 9565 2840 9640 { lab=Vg}
N 2525 9640 2840 9640 { lab=Vg}
N 2520 9565 2520 9640 { lab=Vg}
N 2680 9565 2680 9640 { lab=Vg}
N 2195 9535 2195 9565 { lab=VLX}
N 2330 9535 2330 9565 { lab=VLX}
N 2480 9535 2480 9565 { lab=VLX}
N 2640 9535 2640 9565 { lab=VLX}
N 2800 9535 2800 9565 { lab=VLX}
N 2935 9535 3070 9535 { lab=VLX}
N 3070 9535 3220 9535 { lab=VLX}
N 3220 9535 3380 9535 { lab=VLX}
N 3380 9535 3540 9535 { lab=VLX}
N 2935 9595 3070 9595 { lab=Vout}
N 3070 9595 3220 9595 { lab=Vout}
N 3220 9595 3380 9595 { lab=Vout}
N 3380 9595 3540 9595 { lab=Vout}
N 2975 9565 2975 9640 { lab=Vg}
N 2975 9640 3110 9640 { lab=Vg}
N 3110 9565 3110 9640 { lab=Vg}
N 3110 9640 3265 9640 { lab=Vg}
N 3580 9565 3580 9640 { lab=Vg}
N 3265 9640 3580 9640 { lab=Vg}
N 3260 9565 3260 9640 { lab=Vg}
N 3420 9565 3420 9640 { lab=Vg}
N 2935 9535 2935 9565 { lab=VLX}
N 3070 9535 3070 9565 { lab=VLX}
N 3220 9535 3220 9565 { lab=VLX}
N 3380 9535 3380 9565 { lab=VLX}
N 3540 9535 3540 9565 { lab=VLX}
N 2800 9535 2935 9535 { lab=VLX}
N 2800 9595 2935 9595 { lab=Vout}
N 2840 9640 2975 9640 { lab=Vg}
N 2045 9535 2195 9535 { lab=VLX}
N 2085 9640 2235 9640 { lab=Vg}
N 2045 9595 2195 9595 { lab=Vout}
N 700 9700 835 9700 { lab=VLX}
N 835 9700 985 9700 { lab=VLX}
N 985 9700 1145 9700 { lab=VLX}
N 1145 9700 1305 9700 { lab=VLX}
N 700 9760 835 9760 { lab=Vout}
N 835 9760 985 9760 { lab=Vout}
N 985 9760 1145 9760 { lab=Vout}
N 1145 9760 1305 9760 { lab=Vout}
N 740 9730 740 9805 { lab=Vg}
N 740 9805 875 9805 { lab=Vg}
N 875 9730 875 9805 { lab=Vg}
N 875 9805 1030 9805 { lab=Vg}
N 1345 9730 1345 9805 { lab=Vg}
N 1030 9805 1345 9805 { lab=Vg}
N 1025 9730 1025 9805 { lab=Vg}
N 1185 9730 1185 9805 { lab=Vg}
N 700 9700 700 9730 { lab=VLX}
N 835 9700 835 9730 { lab=VLX}
N 985 9700 985 9730 { lab=VLX}
N 1145 9700 1145 9730 { lab=VLX}
N 1305 9700 1305 9730 { lab=VLX}
N 1440 9700 1575 9700 { lab=VLX}
N 1575 9700 1725 9700 { lab=VLX}
N 1725 9700 1885 9700 { lab=VLX}
N 1885 9700 2045 9700 { lab=VLX}
N 1440 9760 1575 9760 { lab=Vout}
N 1575 9760 1725 9760 { lab=Vout}
N 1725 9760 1885 9760 { lab=Vout}
N 1885 9760 2045 9760 { lab=Vout}
N 1480 9730 1480 9805 { lab=Vg}
N 1480 9805 1615 9805 { lab=Vg}
N 1615 9730 1615 9805 { lab=Vg}
N 1615 9805 1770 9805 { lab=Vg}
N 2085 9730 2085 9805 { lab=Vg}
N 1770 9805 2085 9805 { lab=Vg}
N 1765 9730 1765 9805 { lab=Vg}
N 1925 9730 1925 9805 { lab=Vg}
N 1440 9700 1440 9730 { lab=VLX}
N 1575 9700 1575 9730 { lab=VLX}
N 1725 9700 1725 9730 { lab=VLX}
N 1885 9700 1885 9730 { lab=VLX}
N 2045 9700 2045 9730 { lab=VLX}
N 1305 9700 1440 9700 { lab=VLX}
N 1305 9760 1440 9760 { lab=Vout}
N 1345 9805 1480 9805 { lab=Vg}
N 2195 9700 2330 9700 { lab=VLX}
N 2330 9700 2480 9700 { lab=VLX}
N 2480 9700 2640 9700 { lab=VLX}
N 2640 9700 2800 9700 { lab=VLX}
N 2195 9760 2330 9760 { lab=Vout}
N 2330 9760 2480 9760 { lab=Vout}
N 2480 9760 2640 9760 { lab=Vout}
N 2640 9760 2800 9760 { lab=Vout}
N 2235 9730 2235 9805 { lab=Vg}
N 2235 9805 2370 9805 { lab=Vg}
N 2370 9730 2370 9805 { lab=Vg}
N 2370 9805 2525 9805 { lab=Vg}
N 2840 9730 2840 9805 { lab=Vg}
N 2525 9805 2840 9805 { lab=Vg}
N 2520 9730 2520 9805 { lab=Vg}
N 2680 9730 2680 9805 { lab=Vg}
N 2195 9700 2195 9730 { lab=VLX}
N 2330 9700 2330 9730 { lab=VLX}
N 2480 9700 2480 9730 { lab=VLX}
N 2640 9700 2640 9730 { lab=VLX}
N 2800 9700 2800 9730 { lab=VLX}
N 2935 9700 3070 9700 { lab=VLX}
N 3070 9700 3220 9700 { lab=VLX}
N 3220 9700 3380 9700 { lab=VLX}
N 3380 9700 3540 9700 { lab=VLX}
N 2935 9760 3070 9760 { lab=Vout}
N 3070 9760 3220 9760 { lab=Vout}
N 3220 9760 3380 9760 { lab=Vout}
N 3380 9760 3540 9760 { lab=Vout}
N 2975 9730 2975 9805 { lab=Vg}
N 2975 9805 3110 9805 { lab=Vg}
N 3110 9730 3110 9805 { lab=Vg}
N 3110 9805 3265 9805 { lab=Vg}
N 3580 9730 3580 9805 { lab=Vg}
N 3265 9805 3580 9805 { lab=Vg}
N 3260 9730 3260 9805 { lab=Vg}
N 3420 9730 3420 9805 { lab=Vg}
N 2935 9700 2935 9730 { lab=VLX}
N 3070 9700 3070 9730 { lab=VLX}
N 3220 9700 3220 9730 { lab=VLX}
N 3380 9700 3380 9730 { lab=VLX}
N 3540 9700 3540 9730 { lab=VLX}
N 2800 9700 2935 9700 { lab=VLX}
N 2800 9760 2935 9760 { lab=Vout}
N 2840 9805 2975 9805 { lab=Vg}
N 2045 9700 2195 9700 { lab=VLX}
N 2085 9805 2235 9805 { lab=Vg}
N 2045 9760 2195 9760 { lab=Vout}
N 3580 9640 3580 9730 { lab=Vg}
N 455 9535 700 9535 { lab=VLX}
N 450 9700 700 9700 { lab=VLX}
N 450 9535 450 9700 { lab=VLX}
N 450 9535 455 9535 { lab=VLX}
N 570 9595 700 9595 { lab=Vout}
N 570 9595 570 9805 { lab=Vout}
N 450 9350 450 9540 { lab=VLX}
N 570 9450 570 9600 { lab=Vout}
N 3580 9450 3580 9570 { lab=Vg}
N 700 9855 835 9855 { lab=VLX}
N 835 9855 985 9855 { lab=VLX}
N 985 9855 1145 9855 { lab=VLX}
N 1145 9855 1305 9855 { lab=VLX}
N 700 9915 835 9915 { lab=Vout}
N 835 9915 985 9915 { lab=Vout}
N 985 9915 1145 9915 { lab=Vout}
N 1145 9915 1305 9915 { lab=Vout}
N 740 9885 740 9960 { lab=Vg}
N 740 9960 875 9960 { lab=Vg}
N 875 9885 875 9960 { lab=Vg}
N 875 9960 1030 9960 { lab=Vg}
N 1345 9885 1345 9960 { lab=Vg}
N 1030 9960 1345 9960 { lab=Vg}
N 1025 9885 1025 9960 { lab=Vg}
N 1185 9885 1185 9960 { lab=Vg}
N 700 9855 700 9885 { lab=VLX}
N 835 9855 835 9885 { lab=VLX}
N 985 9855 985 9885 { lab=VLX}
N 1145 9855 1145 9885 { lab=VLX}
N 1305 9855 1305 9885 { lab=VLX}
N 1440 9855 1575 9855 { lab=VLX}
N 1575 9855 1725 9855 { lab=VLX}
N 1725 9855 1885 9855 { lab=VLX}
N 1885 9855 2045 9855 { lab=VLX}
N 1440 9915 1575 9915 { lab=Vout}
N 1575 9915 1725 9915 { lab=Vout}
N 1725 9915 1885 9915 { lab=Vout}
N 1885 9915 2045 9915 { lab=Vout}
N 1480 9885 1480 9960 { lab=Vg}
N 1480 9960 1615 9960 { lab=Vg}
N 1615 9885 1615 9960 { lab=Vg}
N 1615 9960 1770 9960 { lab=Vg}
N 2085 9885 2085 9960 { lab=Vg}
N 1770 9960 2085 9960 { lab=Vg}
N 1765 9885 1765 9960 { lab=Vg}
N 1925 9885 1925 9960 { lab=Vg}
N 1440 9855 1440 9885 { lab=VLX}
N 1575 9855 1575 9885 { lab=VLX}
N 1725 9855 1725 9885 { lab=VLX}
N 1885 9855 1885 9885 { lab=VLX}
N 2045 9855 2045 9885 { lab=VLX}
N 1305 9855 1440 9855 { lab=VLX}
N 1305 9915 1440 9915 { lab=Vout}
N 1345 9960 1480 9960 { lab=Vg}
N 2195 9855 2330 9855 { lab=VLX}
N 2330 9855 2480 9855 { lab=VLX}
N 2480 9855 2640 9855 { lab=VLX}
N 2640 9855 2800 9855 { lab=VLX}
N 2195 9915 2330 9915 { lab=Vout}
N 2330 9915 2480 9915 { lab=Vout}
N 2480 9915 2640 9915 { lab=Vout}
N 2640 9915 2800 9915 { lab=Vout}
N 2235 9885 2235 9960 { lab=Vg}
N 2235 9960 2370 9960 { lab=Vg}
N 2370 9885 2370 9960 { lab=Vg}
N 2370 9960 2525 9960 { lab=Vg}
N 2840 9885 2840 9960 { lab=Vg}
N 2525 9960 2840 9960 { lab=Vg}
N 2520 9885 2520 9960 { lab=Vg}
N 2680 9885 2680 9960 { lab=Vg}
N 2195 9855 2195 9885 { lab=VLX}
N 2330 9855 2330 9885 { lab=VLX}
N 2480 9855 2480 9885 { lab=VLX}
N 2640 9855 2640 9885 { lab=VLX}
N 2800 9855 2800 9885 { lab=VLX}
N 2935 9855 3070 9855 { lab=VLX}
N 3070 9855 3220 9855 { lab=VLX}
N 3220 9855 3380 9855 { lab=VLX}
N 3380 9855 3540 9855 { lab=VLX}
N 2935 9915 3070 9915 { lab=Vout}
N 3070 9915 3220 9915 { lab=Vout}
N 3220 9915 3380 9915 { lab=Vout}
N 3380 9915 3540 9915 { lab=Vout}
N 2975 9885 2975 9960 { lab=Vg}
N 2975 9960 3110 9960 { lab=Vg}
N 3110 9885 3110 9960 { lab=Vg}
N 3110 9960 3265 9960 { lab=Vg}
N 3580 9885 3580 9960 { lab=Vg}
N 3265 9960 3580 9960 { lab=Vg}
N 3260 9885 3260 9960 { lab=Vg}
N 3420 9885 3420 9960 { lab=Vg}
N 2935 9855 2935 9885 { lab=VLX}
N 3070 9855 3070 9885 { lab=VLX}
N 3220 9855 3220 9885 { lab=VLX}
N 3380 9855 3380 9885 { lab=VLX}
N 3540 9855 3540 9885 { lab=VLX}
N 2800 9855 2935 9855 { lab=VLX}
N 2800 9915 2935 9915 { lab=Vout}
N 2840 9960 2975 9960 { lab=Vg}
N 2045 9855 2195 9855 { lab=VLX}
N 2085 9960 2235 9960 { lab=Vg}
N 2045 9915 2195 9915 { lab=Vout}
N 700 10020 835 10020 { lab=VLX}
N 835 10020 985 10020 { lab=VLX}
N 985 10020 1145 10020 { lab=VLX}
N 1145 10020 1305 10020 { lab=VLX}
N 700 10080 835 10080 { lab=Vout}
N 835 10080 985 10080 { lab=Vout}
N 985 10080 1145 10080 { lab=Vout}
N 1145 10080 1305 10080 { lab=Vout}
N 740 10050 740 10125 { lab=Vg}
N 740 10125 875 10125 { lab=Vg}
N 875 10050 875 10125 { lab=Vg}
N 875 10125 1030 10125 { lab=Vg}
N 1345 10050 1345 10125 { lab=Vg}
N 1030 10125 1345 10125 { lab=Vg}
N 1025 10050 1025 10125 { lab=Vg}
N 1185 10050 1185 10125 { lab=Vg}
N 700 10020 700 10050 { lab=VLX}
N 835 10020 835 10050 { lab=VLX}
N 985 10020 985 10050 { lab=VLX}
N 1145 10020 1145 10050 { lab=VLX}
N 1305 10020 1305 10050 { lab=VLX}
N 1440 10020 1575 10020 { lab=VLX}
N 1575 10020 1725 10020 { lab=VLX}
N 1725 10020 1885 10020 { lab=VLX}
N 1885 10020 2045 10020 { lab=VLX}
N 1440 10080 1575 10080 { lab=Vout}
N 1575 10080 1725 10080 { lab=Vout}
N 1725 10080 1885 10080 { lab=Vout}
N 1885 10080 2045 10080 { lab=Vout}
N 1480 10050 1480 10125 { lab=Vg}
N 1480 10125 1615 10125 { lab=Vg}
N 1615 10050 1615 10125 { lab=Vg}
N 1615 10125 1770 10125 { lab=Vg}
N 2085 10050 2085 10125 { lab=Vg}
N 1770 10125 2085 10125 { lab=Vg}
N 1765 10050 1765 10125 { lab=Vg}
N 1925 10050 1925 10125 { lab=Vg}
N 1440 10020 1440 10050 { lab=VLX}
N 1575 10020 1575 10050 { lab=VLX}
N 1725 10020 1725 10050 { lab=VLX}
N 1885 10020 1885 10050 { lab=VLX}
N 2045 10020 2045 10050 { lab=VLX}
N 1305 10020 1440 10020 { lab=VLX}
N 1305 10080 1440 10080 { lab=Vout}
N 1345 10125 1480 10125 { lab=Vg}
N 2195 10020 2330 10020 { lab=VLX}
N 2330 10020 2480 10020 { lab=VLX}
N 2480 10020 2640 10020 { lab=VLX}
N 2640 10020 2800 10020 { lab=VLX}
N 2195 10080 2330 10080 { lab=Vout}
N 2330 10080 2480 10080 { lab=Vout}
N 2480 10080 2640 10080 { lab=Vout}
N 2640 10080 2800 10080 { lab=Vout}
N 2235 10050 2235 10125 { lab=Vg}
N 2235 10125 2370 10125 { lab=Vg}
N 2370 10050 2370 10125 { lab=Vg}
N 2370 10125 2525 10125 { lab=Vg}
N 2840 10050 2840 10125 { lab=Vg}
N 2525 10125 2840 10125 { lab=Vg}
N 2520 10050 2520 10125 { lab=Vg}
N 2680 10050 2680 10125 { lab=Vg}
N 2195 10020 2195 10050 { lab=VLX}
N 2330 10020 2330 10050 { lab=VLX}
N 2480 10020 2480 10050 { lab=VLX}
N 2640 10020 2640 10050 { lab=VLX}
N 2800 10020 2800 10050 { lab=VLX}
N 2935 10020 3070 10020 { lab=VLX}
N 3070 10020 3220 10020 { lab=VLX}
N 3220 10020 3380 10020 { lab=VLX}
N 3380 10020 3540 10020 { lab=VLX}
N 2935 10080 3070 10080 { lab=Vout}
N 3070 10080 3220 10080 { lab=Vout}
N 3220 10080 3380 10080 { lab=Vout}
N 3380 10080 3540 10080 { lab=Vout}
N 2975 10050 2975 10125 { lab=Vg}
N 2975 10125 3110 10125 { lab=Vg}
N 3110 10050 3110 10125 { lab=Vg}
N 3110 10125 3265 10125 { lab=Vg}
N 3580 10050 3580 10125 { lab=Vg}
N 3265 10125 3580 10125 { lab=Vg}
N 3260 10050 3260 10125 { lab=Vg}
N 3420 10050 3420 10125 { lab=Vg}
N 2935 10020 2935 10050 { lab=VLX}
N 3070 10020 3070 10050 { lab=VLX}
N 3220 10020 3220 10050 { lab=VLX}
N 3380 10020 3380 10050 { lab=VLX}
N 3540 10020 3540 10050 { lab=VLX}
N 2800 10020 2935 10020 { lab=VLX}
N 2800 10080 2935 10080 { lab=Vout}
N 2840 10125 2975 10125 { lab=Vg}
N 2045 10020 2195 10020 { lab=VLX}
N 2085 10125 2235 10125 { lab=Vg}
N 2045 10080 2195 10080 { lab=Vout}
N 3580 9960 3580 10050 { lab=Vg}
N 455 9855 700 9855 { lab=VLX}
N 450 10020 700 10020 { lab=VLX}
N 450 9855 450 10020 { lab=VLX}
N 450 9855 455 9855 { lab=VLX}
N 570 9915 700 9915 { lab=Vout}
N 570 9915 570 10125 { lab=Vout}
N 700 10205 835 10205 { lab=VLX}
N 835 10205 985 10205 { lab=VLX}
N 985 10205 1145 10205 { lab=VLX}
N 1145 10205 1305 10205 { lab=VLX}
N 700 10265 835 10265 { lab=Vout}
N 835 10265 985 10265 { lab=Vout}
N 985 10265 1145 10265 { lab=Vout}
N 1145 10265 1305 10265 { lab=Vout}
N 740 10235 740 10310 { lab=Vg}
N 740 10310 875 10310 { lab=Vg}
N 875 10235 875 10310 { lab=Vg}
N 875 10310 1030 10310 { lab=Vg}
N 1345 10235 1345 10310 { lab=Vg}
N 1030 10310 1345 10310 { lab=Vg}
N 1025 10235 1025 10310 { lab=Vg}
N 1185 10235 1185 10310 { lab=Vg}
N 700 10205 700 10235 { lab=VLX}
N 835 10205 835 10235 { lab=VLX}
N 985 10205 985 10235 { lab=VLX}
N 1145 10205 1145 10235 { lab=VLX}
N 1305 10205 1305 10235 { lab=VLX}
N 1440 10205 1575 10205 { lab=VLX}
N 1575 10205 1725 10205 { lab=VLX}
N 1725 10205 1885 10205 { lab=VLX}
N 1885 10205 2045 10205 { lab=VLX}
N 1440 10265 1575 10265 { lab=Vout}
N 1575 10265 1725 10265 { lab=Vout}
N 1725 10265 1885 10265 { lab=Vout}
N 1885 10265 2045 10265 { lab=Vout}
N 1480 10235 1480 10310 { lab=Vg}
N 1480 10310 1615 10310 { lab=Vg}
N 1615 10235 1615 10310 { lab=Vg}
N 1615 10310 1770 10310 { lab=Vg}
N 2085 10235 2085 10310 { lab=Vg}
N 1770 10310 2085 10310 { lab=Vg}
N 1765 10235 1765 10310 { lab=Vg}
N 1925 10235 1925 10310 { lab=Vg}
N 1440 10205 1440 10235 { lab=VLX}
N 1575 10205 1575 10235 { lab=VLX}
N 1725 10205 1725 10235 { lab=VLX}
N 1885 10205 1885 10235 { lab=VLX}
N 2045 10205 2045 10235 { lab=VLX}
N 1305 10205 1440 10205 { lab=VLX}
N 1305 10265 1440 10265 { lab=Vout}
N 1345 10310 1480 10310 { lab=Vg}
N 2195 10205 2330 10205 { lab=VLX}
N 2330 10205 2480 10205 { lab=VLX}
N 2480 10205 2640 10205 { lab=VLX}
N 2640 10205 2800 10205 { lab=VLX}
N 2195 10265 2330 10265 { lab=Vout}
N 2330 10265 2480 10265 { lab=Vout}
N 2480 10265 2640 10265 { lab=Vout}
N 2640 10265 2800 10265 { lab=Vout}
N 2235 10235 2235 10310 { lab=Vg}
N 2235 10310 2370 10310 { lab=Vg}
N 2370 10235 2370 10310 { lab=Vg}
N 2370 10310 2525 10310 { lab=Vg}
N 2840 10235 2840 10310 { lab=Vg}
N 2525 10310 2840 10310 { lab=Vg}
N 2520 10235 2520 10310 { lab=Vg}
N 2680 10235 2680 10310 { lab=Vg}
N 2195 10205 2195 10235 { lab=VLX}
N 2330 10205 2330 10235 { lab=VLX}
N 2480 10205 2480 10235 { lab=VLX}
N 2640 10205 2640 10235 { lab=VLX}
N 2800 10205 2800 10235 { lab=VLX}
N 2935 10205 3070 10205 { lab=VLX}
N 3070 10205 3220 10205 { lab=VLX}
N 3220 10205 3380 10205 { lab=VLX}
N 3380 10205 3540 10205 { lab=VLX}
N 2935 10265 3070 10265 { lab=Vout}
N 3070 10265 3220 10265 { lab=Vout}
N 3220 10265 3380 10265 { lab=Vout}
N 3380 10265 3540 10265 { lab=Vout}
N 2975 10235 2975 10310 { lab=Vg}
N 2975 10310 3110 10310 { lab=Vg}
N 3110 10235 3110 10310 { lab=Vg}
N 3110 10310 3265 10310 { lab=Vg}
N 3580 10235 3580 10310 { lab=Vg}
N 3265 10310 3580 10310 { lab=Vg}
N 3260 10235 3260 10310 { lab=Vg}
N 3420 10235 3420 10310 { lab=Vg}
N 2935 10205 2935 10235 { lab=VLX}
N 3070 10205 3070 10235 { lab=VLX}
N 3220 10205 3220 10235 { lab=VLX}
N 3380 10205 3380 10235 { lab=VLX}
N 3540 10205 3540 10235 { lab=VLX}
N 2800 10205 2935 10205 { lab=VLX}
N 2800 10265 2935 10265 { lab=Vout}
N 2840 10310 2975 10310 { lab=Vg}
N 2045 10205 2195 10205 { lab=VLX}
N 2085 10310 2235 10310 { lab=Vg}
N 2045 10265 2195 10265 { lab=Vout}
N 700 10370 835 10370 { lab=VLX}
N 835 10370 985 10370 { lab=VLX}
N 985 10370 1145 10370 { lab=VLX}
N 1145 10370 1305 10370 { lab=VLX}
N 700 10430 835 10430 { lab=Vout}
N 835 10430 985 10430 { lab=Vout}
N 985 10430 1145 10430 { lab=Vout}
N 1145 10430 1305 10430 { lab=Vout}
N 740 10400 740 10475 { lab=Vg}
N 740 10475 875 10475 { lab=Vg}
N 875 10400 875 10475 { lab=Vg}
N 875 10475 1030 10475 { lab=Vg}
N 1345 10400 1345 10475 { lab=Vg}
N 1030 10475 1345 10475 { lab=Vg}
N 1025 10400 1025 10475 { lab=Vg}
N 1185 10400 1185 10475 { lab=Vg}
N 700 10370 700 10400 { lab=VLX}
N 835 10370 835 10400 { lab=VLX}
N 985 10370 985 10400 { lab=VLX}
N 1145 10370 1145 10400 { lab=VLX}
N 1305 10370 1305 10400 { lab=VLX}
N 1440 10370 1575 10370 { lab=VLX}
N 1575 10370 1725 10370 { lab=VLX}
N 1725 10370 1885 10370 { lab=VLX}
N 1885 10370 2045 10370 { lab=VLX}
N 1440 10430 1575 10430 { lab=Vout}
N 1575 10430 1725 10430 { lab=Vout}
N 1725 10430 1885 10430 { lab=Vout}
N 1885 10430 2045 10430 { lab=Vout}
N 1480 10400 1480 10475 { lab=Vg}
N 1480 10475 1615 10475 { lab=Vg}
N 1615 10400 1615 10475 { lab=Vg}
N 1615 10475 1770 10475 { lab=Vg}
N 2085 10400 2085 10475 { lab=Vg}
N 1770 10475 2085 10475 { lab=Vg}
N 1765 10400 1765 10475 { lab=Vg}
N 1925 10400 1925 10475 { lab=Vg}
N 1440 10370 1440 10400 { lab=VLX}
N 1575 10370 1575 10400 { lab=VLX}
N 1725 10370 1725 10400 { lab=VLX}
N 1885 10370 1885 10400 { lab=VLX}
N 2045 10370 2045 10400 { lab=VLX}
N 1305 10370 1440 10370 { lab=VLX}
N 1305 10430 1440 10430 { lab=Vout}
N 1345 10475 1480 10475 { lab=Vg}
N 2195 10370 2330 10370 { lab=VLX}
N 2330 10370 2480 10370 { lab=VLX}
N 2480 10370 2640 10370 { lab=VLX}
N 2640 10370 2800 10370 { lab=VLX}
N 2195 10430 2330 10430 { lab=Vout}
N 2330 10430 2480 10430 { lab=Vout}
N 2480 10430 2640 10430 { lab=Vout}
N 2640 10430 2800 10430 { lab=Vout}
N 2235 10400 2235 10475 { lab=Vg}
N 2235 10475 2370 10475 { lab=Vg}
N 2370 10400 2370 10475 { lab=Vg}
N 2370 10475 2525 10475 { lab=Vg}
N 2840 10400 2840 10475 { lab=Vg}
N 2525 10475 2840 10475 { lab=Vg}
N 2520 10400 2520 10475 { lab=Vg}
N 2680 10400 2680 10475 { lab=Vg}
N 2195 10370 2195 10400 { lab=VLX}
N 2330 10370 2330 10400 { lab=VLX}
N 2480 10370 2480 10400 { lab=VLX}
N 2640 10370 2640 10400 { lab=VLX}
N 2800 10370 2800 10400 { lab=VLX}
N 2935 10370 3070 10370 { lab=VLX}
N 3070 10370 3220 10370 { lab=VLX}
N 3220 10370 3380 10370 { lab=VLX}
N 3380 10370 3540 10370 { lab=VLX}
N 2935 10430 3070 10430 { lab=Vout}
N 3070 10430 3220 10430 { lab=Vout}
N 3220 10430 3380 10430 { lab=Vout}
N 3380 10430 3540 10430 { lab=Vout}
N 2975 10400 2975 10475 { lab=Vg}
N 2975 10475 3110 10475 { lab=Vg}
N 3110 10400 3110 10475 { lab=Vg}
N 3110 10475 3265 10475 { lab=Vg}
N 3580 10400 3580 10475 { lab=Vg}
N 3265 10475 3580 10475 { lab=Vg}
N 3260 10400 3260 10475 { lab=Vg}
N 3420 10400 3420 10475 { lab=Vg}
N 2935 10370 2935 10400 { lab=VLX}
N 3070 10370 3070 10400 { lab=VLX}
N 3220 10370 3220 10400 { lab=VLX}
N 3380 10370 3380 10400 { lab=VLX}
N 3540 10370 3540 10400 { lab=VLX}
N 2800 10370 2935 10370 { lab=VLX}
N 2800 10430 2935 10430 { lab=Vout}
N 2840 10475 2975 10475 { lab=Vg}
N 2045 10370 2195 10370 { lab=VLX}
N 2085 10475 2235 10475 { lab=Vg}
N 2045 10430 2195 10430 { lab=Vout}
N 3580 10310 3580 10400 { lab=Vg}
N 455 10205 700 10205 { lab=VLX}
N 450 10370 700 10370 { lab=VLX}
N 450 10205 450 10370 { lab=VLX}
N 450 10205 455 10205 { lab=VLX}
N 570 10265 700 10265 { lab=Vout}
N 570 10265 570 10475 { lab=Vout}
N 450 10020 450 10210 { lab=VLX}
N 570 10120 570 10270 { lab=Vout}
N 3580 10120 3580 10240 { lab=Vg}
N 450 9700 450 9860 { lab=VLX}
N 570 9800 570 9920 { lab=Vout}
N 3580 9810 3580 9880 { lab=Vg}
N 3580 9800 3580 9810 { lab=Vg}
N 700 10605 835 10605 { lab=VLX}
N 835 10605 985 10605 { lab=VLX}
N 985 10605 1145 10605 { lab=VLX}
N 1145 10605 1305 10605 { lab=VLX}
N 700 10665 835 10665 { lab=Vout}
N 835 10665 985 10665 { lab=Vout}
N 985 10665 1145 10665 { lab=Vout}
N 1145 10665 1305 10665 { lab=Vout}
N 740 10635 740 10710 { lab=Vg}
N 740 10710 875 10710 { lab=Vg}
N 875 10635 875 10710 { lab=Vg}
N 875 10710 1030 10710 { lab=Vg}
N 1345 10635 1345 10710 { lab=Vg}
N 1030 10710 1345 10710 { lab=Vg}
N 1025 10635 1025 10710 { lab=Vg}
N 1185 10635 1185 10710 { lab=Vg}
N 700 10605 700 10635 { lab=VLX}
N 835 10605 835 10635 { lab=VLX}
N 985 10605 985 10635 { lab=VLX}
N 1145 10605 1145 10635 { lab=VLX}
N 1305 10605 1305 10635 { lab=VLX}
N 1440 10605 1575 10605 { lab=VLX}
N 1575 10605 1725 10605 { lab=VLX}
N 1725 10605 1885 10605 { lab=VLX}
N 1885 10605 2045 10605 { lab=VLX}
N 1440 10665 1575 10665 { lab=Vout}
N 1575 10665 1725 10665 { lab=Vout}
N 1725 10665 1885 10665 { lab=Vout}
N 1885 10665 2045 10665 { lab=Vout}
N 1480 10635 1480 10710 { lab=Vg}
N 1480 10710 1615 10710 { lab=Vg}
N 1615 10635 1615 10710 { lab=Vg}
N 1615 10710 1770 10710 { lab=Vg}
N 2085 10635 2085 10710 { lab=Vg}
N 1770 10710 2085 10710 { lab=Vg}
N 1765 10635 1765 10710 { lab=Vg}
N 1925 10635 1925 10710 { lab=Vg}
N 1440 10605 1440 10635 { lab=VLX}
N 1575 10605 1575 10635 { lab=VLX}
N 1725 10605 1725 10635 { lab=VLX}
N 1885 10605 1885 10635 { lab=VLX}
N 2045 10605 2045 10635 { lab=VLX}
N 1305 10605 1440 10605 { lab=VLX}
N 1305 10665 1440 10665 { lab=Vout}
N 1345 10710 1480 10710 { lab=Vg}
N 2195 10605 2330 10605 { lab=VLX}
N 2330 10605 2480 10605 { lab=VLX}
N 2480 10605 2640 10605 { lab=VLX}
N 2640 10605 2800 10605 { lab=VLX}
N 2195 10665 2330 10665 { lab=Vout}
N 2330 10665 2480 10665 { lab=Vout}
N 2480 10665 2640 10665 { lab=Vout}
N 2640 10665 2800 10665 { lab=Vout}
N 2235 10635 2235 10710 { lab=Vg}
N 2235 10710 2370 10710 { lab=Vg}
N 2370 10635 2370 10710 { lab=Vg}
N 2370 10710 2525 10710 { lab=Vg}
N 2840 10635 2840 10710 { lab=Vg}
N 2525 10710 2840 10710 { lab=Vg}
N 2520 10635 2520 10710 { lab=Vg}
N 2680 10635 2680 10710 { lab=Vg}
N 2195 10605 2195 10635 { lab=VLX}
N 2330 10605 2330 10635 { lab=VLX}
N 2480 10605 2480 10635 { lab=VLX}
N 2640 10605 2640 10635 { lab=VLX}
N 2800 10605 2800 10635 { lab=VLX}
N 2935 10605 3070 10605 { lab=VLX}
N 3070 10605 3220 10605 { lab=VLX}
N 3220 10605 3380 10605 { lab=VLX}
N 3380 10605 3540 10605 { lab=VLX}
N 2935 10665 3070 10665 { lab=Vout}
N 3070 10665 3220 10665 { lab=Vout}
N 3220 10665 3380 10665 { lab=Vout}
N 3380 10665 3540 10665 { lab=Vout}
N 2975 10635 2975 10710 { lab=Vg}
N 2975 10710 3110 10710 { lab=Vg}
N 3110 10635 3110 10710 { lab=Vg}
N 3110 10710 3265 10710 { lab=Vg}
N 3580 10635 3580 10710 { lab=Vg}
N 3265 10710 3580 10710 { lab=Vg}
N 3260 10635 3260 10710 { lab=Vg}
N 3420 10635 3420 10710 { lab=Vg}
N 2935 10605 2935 10635 { lab=VLX}
N 3070 10605 3070 10635 { lab=VLX}
N 3220 10605 3220 10635 { lab=VLX}
N 3380 10605 3380 10635 { lab=VLX}
N 3540 10605 3540 10635 { lab=VLX}
N 2800 10605 2935 10605 { lab=VLX}
N 2800 10665 2935 10665 { lab=Vout}
N 2840 10710 2975 10710 { lab=Vg}
N 2045 10605 2195 10605 { lab=VLX}
N 2085 10710 2235 10710 { lab=Vg}
N 2045 10665 2195 10665 { lab=Vout}
N 700 10770 835 10770 { lab=VLX}
N 835 10770 985 10770 { lab=VLX}
N 985 10770 1145 10770 { lab=VLX}
N 1145 10770 1305 10770 { lab=VLX}
N 700 10830 835 10830 { lab=Vout}
N 835 10830 985 10830 { lab=Vout}
N 985 10830 1145 10830 { lab=Vout}
N 1145 10830 1305 10830 { lab=Vout}
N 740 10800 740 10875 { lab=Vg}
N 740 10875 875 10875 { lab=Vg}
N 875 10800 875 10875 { lab=Vg}
N 875 10875 1030 10875 { lab=Vg}
N 1345 10800 1345 10875 { lab=Vg}
N 1030 10875 1345 10875 { lab=Vg}
N 1025 10800 1025 10875 { lab=Vg}
N 1185 10800 1185 10875 { lab=Vg}
N 700 10770 700 10800 { lab=VLX}
N 835 10770 835 10800 { lab=VLX}
N 985 10770 985 10800 { lab=VLX}
N 1145 10770 1145 10800 { lab=VLX}
N 1305 10770 1305 10800 { lab=VLX}
N 1440 10770 1575 10770 { lab=VLX}
N 1575 10770 1725 10770 { lab=VLX}
N 1725 10770 1885 10770 { lab=VLX}
N 1885 10770 2045 10770 { lab=VLX}
N 1440 10830 1575 10830 { lab=Vout}
N 1575 10830 1725 10830 { lab=Vout}
N 1725 10830 1885 10830 { lab=Vout}
N 1885 10830 2045 10830 { lab=Vout}
N 1480 10800 1480 10875 { lab=Vg}
N 1480 10875 1615 10875 { lab=Vg}
N 1615 10800 1615 10875 { lab=Vg}
N 1615 10875 1770 10875 { lab=Vg}
N 2085 10800 2085 10875 { lab=Vg}
N 1770 10875 2085 10875 { lab=Vg}
N 1765 10800 1765 10875 { lab=Vg}
N 1925 10800 1925 10875 { lab=Vg}
N 1440 10770 1440 10800 { lab=VLX}
N 1575 10770 1575 10800 { lab=VLX}
N 1725 10770 1725 10800 { lab=VLX}
N 1885 10770 1885 10800 { lab=VLX}
N 2045 10770 2045 10800 { lab=VLX}
N 1305 10770 1440 10770 { lab=VLX}
N 1305 10830 1440 10830 { lab=Vout}
N 1345 10875 1480 10875 { lab=Vg}
N 2195 10770 2330 10770 { lab=VLX}
N 2330 10770 2480 10770 { lab=VLX}
N 2480 10770 2640 10770 { lab=VLX}
N 2640 10770 2800 10770 { lab=VLX}
N 2195 10830 2330 10830 { lab=Vout}
N 2330 10830 2480 10830 { lab=Vout}
N 2480 10830 2640 10830 { lab=Vout}
N 2640 10830 2800 10830 { lab=Vout}
N 2235 10800 2235 10875 { lab=Vg}
N 2235 10875 2370 10875 { lab=Vg}
N 2370 10800 2370 10875 { lab=Vg}
N 2370 10875 2525 10875 { lab=Vg}
N 2840 10800 2840 10875 { lab=Vg}
N 2525 10875 2840 10875 { lab=Vg}
N 2520 10800 2520 10875 { lab=Vg}
N 2680 10800 2680 10875 { lab=Vg}
N 2195 10770 2195 10800 { lab=VLX}
N 2330 10770 2330 10800 { lab=VLX}
N 2480 10770 2480 10800 { lab=VLX}
N 2640 10770 2640 10800 { lab=VLX}
N 2800 10770 2800 10800 { lab=VLX}
N 2935 10770 3070 10770 { lab=VLX}
N 3070 10770 3220 10770 { lab=VLX}
N 3220 10770 3380 10770 { lab=VLX}
N 3380 10770 3540 10770 { lab=VLX}
N 2935 10830 3070 10830 { lab=Vout}
N 3070 10830 3220 10830 { lab=Vout}
N 3220 10830 3380 10830 { lab=Vout}
N 3380 10830 3540 10830 { lab=Vout}
N 2975 10800 2975 10875 { lab=Vg}
N 2975 10875 3110 10875 { lab=Vg}
N 3110 10800 3110 10875 { lab=Vg}
N 3110 10875 3265 10875 { lab=Vg}
N 3580 10800 3580 10875 { lab=Vg}
N 3265 10875 3580 10875 { lab=Vg}
N 3260 10800 3260 10875 { lab=Vg}
N 3420 10800 3420 10875 { lab=Vg}
N 2935 10770 2935 10800 { lab=VLX}
N 3070 10770 3070 10800 { lab=VLX}
N 3220 10770 3220 10800 { lab=VLX}
N 3380 10770 3380 10800 { lab=VLX}
N 3540 10770 3540 10800 { lab=VLX}
N 2800 10770 2935 10770 { lab=VLX}
N 2800 10830 2935 10830 { lab=Vout}
N 2840 10875 2975 10875 { lab=Vg}
N 2045 10770 2195 10770 { lab=VLX}
N 2085 10875 2235 10875 { lab=Vg}
N 2045 10830 2195 10830 { lab=Vout}
N 3580 10710 3580 10800 { lab=Vg}
N 455 10605 700 10605 { lab=VLX}
N 450 10770 700 10770 { lab=VLX}
N 450 10605 450 10770 { lab=VLX}
N 450 10605 455 10605 { lab=VLX}
N 570 10665 700 10665 { lab=Vout}
N 570 10665 570 10875 { lab=Vout}
N 700 10955 835 10955 { lab=VLX}
N 835 10955 985 10955 { lab=VLX}
N 985 10955 1145 10955 { lab=VLX}
N 1145 10955 1305 10955 { lab=VLX}
N 700 11015 835 11015 { lab=Vout}
N 835 11015 985 11015 { lab=Vout}
N 985 11015 1145 11015 { lab=Vout}
N 1145 11015 1305 11015 { lab=Vout}
N 740 10985 740 11060 { lab=Vg}
N 740 11060 875 11060 { lab=Vg}
N 875 10985 875 11060 { lab=Vg}
N 875 11060 1030 11060 { lab=Vg}
N 1345 10985 1345 11060 { lab=Vg}
N 1030 11060 1345 11060 { lab=Vg}
N 1025 10985 1025 11060 { lab=Vg}
N 1185 10985 1185 11060 { lab=Vg}
N 700 10955 700 10985 { lab=VLX}
N 835 10955 835 10985 { lab=VLX}
N 985 10955 985 10985 { lab=VLX}
N 1145 10955 1145 10985 { lab=VLX}
N 1305 10955 1305 10985 { lab=VLX}
N 1440 10955 1575 10955 { lab=VLX}
N 1575 10955 1725 10955 { lab=VLX}
N 1725 10955 1885 10955 { lab=VLX}
N 1885 10955 2045 10955 { lab=VLX}
N 1440 11015 1575 11015 { lab=Vout}
N 1575 11015 1725 11015 { lab=Vout}
N 1725 11015 1885 11015 { lab=Vout}
N 1885 11015 2045 11015 { lab=Vout}
N 1480 10985 1480 11060 { lab=Vg}
N 1480 11060 1615 11060 { lab=Vg}
N 1615 10985 1615 11060 { lab=Vg}
N 1615 11060 1770 11060 { lab=Vg}
N 2085 10985 2085 11060 { lab=Vg}
N 1770 11060 2085 11060 { lab=Vg}
N 1765 10985 1765 11060 { lab=Vg}
N 1925 10985 1925 11060 { lab=Vg}
N 1440 10955 1440 10985 { lab=VLX}
N 1575 10955 1575 10985 { lab=VLX}
N 1725 10955 1725 10985 { lab=VLX}
N 1885 10955 1885 10985 { lab=VLX}
N 2045 10955 2045 10985 { lab=VLX}
N 1305 10955 1440 10955 { lab=VLX}
N 1305 11015 1440 11015 { lab=Vout}
N 1345 11060 1480 11060 { lab=Vg}
N 2195 10955 2330 10955 { lab=VLX}
N 2330 10955 2480 10955 { lab=VLX}
N 2480 10955 2640 10955 { lab=VLX}
N 2640 10955 2800 10955 { lab=VLX}
N 2195 11015 2330 11015 { lab=Vout}
N 2330 11015 2480 11015 { lab=Vout}
N 2480 11015 2640 11015 { lab=Vout}
N 2640 11015 2800 11015 { lab=Vout}
N 2235 10985 2235 11060 { lab=Vg}
N 2235 11060 2370 11060 { lab=Vg}
N 2370 10985 2370 11060 { lab=Vg}
N 2370 11060 2525 11060 { lab=Vg}
N 2840 10985 2840 11060 { lab=Vg}
N 2525 11060 2840 11060 { lab=Vg}
N 2520 10985 2520 11060 { lab=Vg}
N 2680 10985 2680 11060 { lab=Vg}
N 2195 10955 2195 10985 { lab=VLX}
N 2330 10955 2330 10985 { lab=VLX}
N 2480 10955 2480 10985 { lab=VLX}
N 2640 10955 2640 10985 { lab=VLX}
N 2800 10955 2800 10985 { lab=VLX}
N 2935 10955 3070 10955 { lab=VLX}
N 3070 10955 3220 10955 { lab=VLX}
N 3220 10955 3380 10955 { lab=VLX}
N 3380 10955 3540 10955 { lab=VLX}
N 2935 11015 3070 11015 { lab=Vout}
N 3070 11015 3220 11015 { lab=Vout}
N 3220 11015 3380 11015 { lab=Vout}
N 3380 11015 3540 11015 { lab=Vout}
N 2975 10985 2975 11060 { lab=Vg}
N 2975 11060 3110 11060 { lab=Vg}
N 3110 10985 3110 11060 { lab=Vg}
N 3110 11060 3265 11060 { lab=Vg}
N 3580 10985 3580 11060 { lab=Vg}
N 3265 11060 3580 11060 { lab=Vg}
N 3260 10985 3260 11060 { lab=Vg}
N 3420 10985 3420 11060 { lab=Vg}
N 2935 10955 2935 10985 { lab=VLX}
N 3070 10955 3070 10985 { lab=VLX}
N 3220 10955 3220 10985 { lab=VLX}
N 3380 10955 3380 10985 { lab=VLX}
N 3540 10955 3540 10985 { lab=VLX}
N 2800 10955 2935 10955 { lab=VLX}
N 2800 11015 2935 11015 { lab=Vout}
N 2840 11060 2975 11060 { lab=Vg}
N 2045 10955 2195 10955 { lab=VLX}
N 2085 11060 2235 11060 { lab=Vg}
N 2045 11015 2195 11015 { lab=Vout}
N 700 11120 835 11120 { lab=VLX}
N 835 11120 985 11120 { lab=VLX}
N 985 11120 1145 11120 { lab=VLX}
N 1145 11120 1305 11120 { lab=VLX}
N 700 11180 835 11180 { lab=Vout}
N 835 11180 985 11180 { lab=Vout}
N 985 11180 1145 11180 { lab=Vout}
N 1145 11180 1305 11180 { lab=Vout}
N 740 11150 740 11225 { lab=Vg}
N 740 11225 875 11225 { lab=Vg}
N 875 11150 875 11225 { lab=Vg}
N 875 11225 1030 11225 { lab=Vg}
N 1345 11150 1345 11225 { lab=Vg}
N 1030 11225 1345 11225 { lab=Vg}
N 1025 11150 1025 11225 { lab=Vg}
N 1185 11150 1185 11225 { lab=Vg}
N 700 11120 700 11150 { lab=VLX}
N 835 11120 835 11150 { lab=VLX}
N 985 11120 985 11150 { lab=VLX}
N 1145 11120 1145 11150 { lab=VLX}
N 1305 11120 1305 11150 { lab=VLX}
N 1440 11120 1575 11120 { lab=VLX}
N 1575 11120 1725 11120 { lab=VLX}
N 1725 11120 1885 11120 { lab=VLX}
N 1885 11120 2045 11120 { lab=VLX}
N 1440 11180 1575 11180 { lab=Vout}
N 1575 11180 1725 11180 { lab=Vout}
N 1725 11180 1885 11180 { lab=Vout}
N 1885 11180 2045 11180 { lab=Vout}
N 1480 11150 1480 11225 { lab=Vg}
N 1480 11225 1615 11225 { lab=Vg}
N 1615 11150 1615 11225 { lab=Vg}
N 1615 11225 1770 11225 { lab=Vg}
N 2085 11150 2085 11225 { lab=Vg}
N 1770 11225 2085 11225 { lab=Vg}
N 1765 11150 1765 11225 { lab=Vg}
N 1925 11150 1925 11225 { lab=Vg}
N 1440 11120 1440 11150 { lab=VLX}
N 1575 11120 1575 11150 { lab=VLX}
N 1725 11120 1725 11150 { lab=VLX}
N 1885 11120 1885 11150 { lab=VLX}
N 2045 11120 2045 11150 { lab=VLX}
N 1305 11120 1440 11120 { lab=VLX}
N 1305 11180 1440 11180 { lab=Vout}
N 1345 11225 1480 11225 { lab=Vg}
N 2195 11120 2330 11120 { lab=VLX}
N 2330 11120 2480 11120 { lab=VLX}
N 2480 11120 2640 11120 { lab=VLX}
N 2640 11120 2800 11120 { lab=VLX}
N 2195 11180 2330 11180 { lab=Vout}
N 2330 11180 2480 11180 { lab=Vout}
N 2480 11180 2640 11180 { lab=Vout}
N 2640 11180 2800 11180 { lab=Vout}
N 2235 11150 2235 11225 { lab=Vg}
N 2235 11225 2370 11225 { lab=Vg}
N 2370 11150 2370 11225 { lab=Vg}
N 2370 11225 2525 11225 { lab=Vg}
N 2840 11150 2840 11225 { lab=Vg}
N 2525 11225 2840 11225 { lab=Vg}
N 2520 11150 2520 11225 { lab=Vg}
N 2680 11150 2680 11225 { lab=Vg}
N 2195 11120 2195 11150 { lab=VLX}
N 2330 11120 2330 11150 { lab=VLX}
N 2480 11120 2480 11150 { lab=VLX}
N 2640 11120 2640 11150 { lab=VLX}
N 2800 11120 2800 11150 { lab=VLX}
N 2935 11120 3070 11120 { lab=VLX}
N 3070 11120 3220 11120 { lab=VLX}
N 3220 11120 3380 11120 { lab=VLX}
N 3380 11120 3540 11120 { lab=VLX}
N 2935 11180 3070 11180 { lab=Vout}
N 3070 11180 3220 11180 { lab=Vout}
N 3220 11180 3380 11180 { lab=Vout}
N 3380 11180 3540 11180 { lab=Vout}
N 2975 11150 2975 11225 { lab=Vg}
N 2975 11225 3110 11225 { lab=Vg}
N 3110 11150 3110 11225 { lab=Vg}
N 3110 11225 3265 11225 { lab=Vg}
N 3580 11150 3580 11225 { lab=Vg}
N 3265 11225 3580 11225 { lab=Vg}
N 3260 11150 3260 11225 { lab=Vg}
N 3420 11150 3420 11225 { lab=Vg}
N 2935 11120 2935 11150 { lab=VLX}
N 3070 11120 3070 11150 { lab=VLX}
N 3220 11120 3220 11150 { lab=VLX}
N 3380 11120 3380 11150 { lab=VLX}
N 3540 11120 3540 11150 { lab=VLX}
N 2800 11120 2935 11120 { lab=VLX}
N 2800 11180 2935 11180 { lab=Vout}
N 2840 11225 2975 11225 { lab=Vg}
N 2045 11120 2195 11120 { lab=VLX}
N 2085 11225 2235 11225 { lab=Vg}
N 2045 11180 2195 11180 { lab=Vout}
N 3580 11060 3580 11150 { lab=Vg}
N 455 10955 700 10955 { lab=VLX}
N 450 11120 700 11120 { lab=VLX}
N 450 10955 450 11120 { lab=VLX}
N 450 10955 455 10955 { lab=VLX}
N 570 11015 700 11015 { lab=Vout}
N 570 11015 570 11225 { lab=Vout}
N 450 10770 450 10960 { lab=VLX}
N 570 10870 570 11020 { lab=Vout}
N 3580 10870 3580 10990 { lab=Vg}
N 700 11275 835 11275 { lab=VLX}
N 835 11275 985 11275 { lab=VLX}
N 985 11275 1145 11275 { lab=VLX}
N 1145 11275 1305 11275 { lab=VLX}
N 700 11335 835 11335 { lab=Vout}
N 835 11335 985 11335 { lab=Vout}
N 985 11335 1145 11335 { lab=Vout}
N 1145 11335 1305 11335 { lab=Vout}
N 740 11305 740 11380 { lab=Vg}
N 740 11380 875 11380 { lab=Vg}
N 875 11305 875 11380 { lab=Vg}
N 875 11380 1030 11380 { lab=Vg}
N 1345 11305 1345 11380 { lab=Vg}
N 1030 11380 1345 11380 { lab=Vg}
N 1025 11305 1025 11380 { lab=Vg}
N 1185 11305 1185 11380 { lab=Vg}
N 700 11275 700 11305 { lab=VLX}
N 835 11275 835 11305 { lab=VLX}
N 985 11275 985 11305 { lab=VLX}
N 1145 11275 1145 11305 { lab=VLX}
N 1305 11275 1305 11305 { lab=VLX}
N 1440 11275 1575 11275 { lab=VLX}
N 1575 11275 1725 11275 { lab=VLX}
N 1725 11275 1885 11275 { lab=VLX}
N 1885 11275 2045 11275 { lab=VLX}
N 1440 11335 1575 11335 { lab=Vout}
N 1575 11335 1725 11335 { lab=Vout}
N 1725 11335 1885 11335 { lab=Vout}
N 1885 11335 2045 11335 { lab=Vout}
N 1480 11305 1480 11380 { lab=Vg}
N 1480 11380 1615 11380 { lab=Vg}
N 1615 11305 1615 11380 { lab=Vg}
N 1615 11380 1770 11380 { lab=Vg}
N 2085 11305 2085 11380 { lab=Vg}
N 1770 11380 2085 11380 { lab=Vg}
N 1765 11305 1765 11380 { lab=Vg}
N 1925 11305 1925 11380 { lab=Vg}
N 1440 11275 1440 11305 { lab=VLX}
N 1575 11275 1575 11305 { lab=VLX}
N 1725 11275 1725 11305 { lab=VLX}
N 1885 11275 1885 11305 { lab=VLX}
N 2045 11275 2045 11305 { lab=VLX}
N 1305 11275 1440 11275 { lab=VLX}
N 1305 11335 1440 11335 { lab=Vout}
N 1345 11380 1480 11380 { lab=Vg}
N 2195 11275 2330 11275 { lab=VLX}
N 2330 11275 2480 11275 { lab=VLX}
N 2480 11275 2640 11275 { lab=VLX}
N 2640 11275 2800 11275 { lab=VLX}
N 2195 11335 2330 11335 { lab=Vout}
N 2330 11335 2480 11335 { lab=Vout}
N 2480 11335 2640 11335 { lab=Vout}
N 2640 11335 2800 11335 { lab=Vout}
N 2235 11305 2235 11380 { lab=Vg}
N 2235 11380 2370 11380 { lab=Vg}
N 2370 11305 2370 11380 { lab=Vg}
N 2370 11380 2525 11380 { lab=Vg}
N 2840 11305 2840 11380 { lab=Vg}
N 2525 11380 2840 11380 { lab=Vg}
N 2520 11305 2520 11380 { lab=Vg}
N 2680 11305 2680 11380 { lab=Vg}
N 2195 11275 2195 11305 { lab=VLX}
N 2330 11275 2330 11305 { lab=VLX}
N 2480 11275 2480 11305 { lab=VLX}
N 2640 11275 2640 11305 { lab=VLX}
N 2800 11275 2800 11305 { lab=VLX}
N 2935 11275 3070 11275 { lab=VLX}
N 3070 11275 3220 11275 { lab=VLX}
N 3220 11275 3380 11275 { lab=VLX}
N 3380 11275 3540 11275 { lab=VLX}
N 2935 11335 3070 11335 { lab=Vout}
N 3070 11335 3220 11335 { lab=Vout}
N 3220 11335 3380 11335 { lab=Vout}
N 3380 11335 3540 11335 { lab=Vout}
N 2975 11305 2975 11380 { lab=Vg}
N 2975 11380 3110 11380 { lab=Vg}
N 3110 11305 3110 11380 { lab=Vg}
N 3110 11380 3265 11380 { lab=Vg}
N 3580 11305 3580 11380 { lab=Vg}
N 3265 11380 3580 11380 { lab=Vg}
N 3260 11305 3260 11380 { lab=Vg}
N 3420 11305 3420 11380 { lab=Vg}
N 2935 11275 2935 11305 { lab=VLX}
N 3070 11275 3070 11305 { lab=VLX}
N 3220 11275 3220 11305 { lab=VLX}
N 3380 11275 3380 11305 { lab=VLX}
N 3540 11275 3540 11305 { lab=VLX}
N 2800 11275 2935 11275 { lab=VLX}
N 2800 11335 2935 11335 { lab=Vout}
N 2840 11380 2975 11380 { lab=Vg}
N 2045 11275 2195 11275 { lab=VLX}
N 2085 11380 2235 11380 { lab=Vg}
N 2045 11335 2195 11335 { lab=Vout}
N 700 11440 835 11440 { lab=VLX}
N 835 11440 985 11440 { lab=VLX}
N 985 11440 1145 11440 { lab=VLX}
N 1145 11440 1305 11440 { lab=VLX}
N 700 11500 835 11500 { lab=Vout}
N 835 11500 985 11500 { lab=Vout}
N 985 11500 1145 11500 { lab=Vout}
N 1145 11500 1305 11500 { lab=Vout}
N 740 11470 740 11545 { lab=Vg}
N 740 11545 875 11545 { lab=Vg}
N 875 11470 875 11545 { lab=Vg}
N 875 11545 1030 11545 { lab=Vg}
N 1345 11470 1345 11545 { lab=Vg}
N 1030 11545 1345 11545 { lab=Vg}
N 1025 11470 1025 11545 { lab=Vg}
N 1185 11470 1185 11545 { lab=Vg}
N 700 11440 700 11470 { lab=VLX}
N 835 11440 835 11470 { lab=VLX}
N 985 11440 985 11470 { lab=VLX}
N 1145 11440 1145 11470 { lab=VLX}
N 1305 11440 1305 11470 { lab=VLX}
N 1440 11440 1575 11440 { lab=VLX}
N 1575 11440 1725 11440 { lab=VLX}
N 1725 11440 1885 11440 { lab=VLX}
N 1885 11440 2045 11440 { lab=VLX}
N 1440 11500 1575 11500 { lab=Vout}
N 1575 11500 1725 11500 { lab=Vout}
N 1725 11500 1885 11500 { lab=Vout}
N 1885 11500 2045 11500 { lab=Vout}
N 1480 11470 1480 11545 { lab=Vg}
N 1480 11545 1615 11545 { lab=Vg}
N 1615 11470 1615 11545 { lab=Vg}
N 1615 11545 1770 11545 { lab=Vg}
N 2085 11470 2085 11545 { lab=Vg}
N 1770 11545 2085 11545 { lab=Vg}
N 1765 11470 1765 11545 { lab=Vg}
N 1925 11470 1925 11545 { lab=Vg}
N 1440 11440 1440 11470 { lab=VLX}
N 1575 11440 1575 11470 { lab=VLX}
N 1725 11440 1725 11470 { lab=VLX}
N 1885 11440 1885 11470 { lab=VLX}
N 2045 11440 2045 11470 { lab=VLX}
N 1305 11440 1440 11440 { lab=VLX}
N 1305 11500 1440 11500 { lab=Vout}
N 1345 11545 1480 11545 { lab=Vg}
N 2195 11440 2330 11440 { lab=VLX}
N 2330 11440 2480 11440 { lab=VLX}
N 2480 11440 2640 11440 { lab=VLX}
N 2640 11440 2800 11440 { lab=VLX}
N 2195 11500 2330 11500 { lab=Vout}
N 2330 11500 2480 11500 { lab=Vout}
N 2480 11500 2640 11500 { lab=Vout}
N 2640 11500 2800 11500 { lab=Vout}
N 2235 11470 2235 11545 { lab=Vg}
N 2235 11545 2370 11545 { lab=Vg}
N 2370 11470 2370 11545 { lab=Vg}
N 2370 11545 2525 11545 { lab=Vg}
N 2840 11470 2840 11545 { lab=Vg}
N 2525 11545 2840 11545 { lab=Vg}
N 2520 11470 2520 11545 { lab=Vg}
N 2680 11470 2680 11545 { lab=Vg}
N 2195 11440 2195 11470 { lab=VLX}
N 2330 11440 2330 11470 { lab=VLX}
N 2480 11440 2480 11470 { lab=VLX}
N 2640 11440 2640 11470 { lab=VLX}
N 2800 11440 2800 11470 { lab=VLX}
N 2935 11440 3070 11440 { lab=VLX}
N 3070 11440 3220 11440 { lab=VLX}
N 3220 11440 3380 11440 { lab=VLX}
N 3380 11440 3540 11440 { lab=VLX}
N 2935 11500 3070 11500 { lab=Vout}
N 3070 11500 3220 11500 { lab=Vout}
N 3220 11500 3380 11500 { lab=Vout}
N 3380 11500 3540 11500 { lab=Vout}
N 2975 11470 2975 11545 { lab=Vg}
N 2975 11545 3110 11545 { lab=Vg}
N 3110 11470 3110 11545 { lab=Vg}
N 3110 11545 3265 11545 { lab=Vg}
N 3580 11470 3580 11545 { lab=Vg}
N 3265 11545 3580 11545 { lab=Vg}
N 3260 11470 3260 11545 { lab=Vg}
N 3420 11470 3420 11545 { lab=Vg}
N 2935 11440 2935 11470 { lab=VLX}
N 3070 11440 3070 11470 { lab=VLX}
N 3220 11440 3220 11470 { lab=VLX}
N 3380 11440 3380 11470 { lab=VLX}
N 3540 11440 3540 11470 { lab=VLX}
N 2800 11440 2935 11440 { lab=VLX}
N 2800 11500 2935 11500 { lab=Vout}
N 2840 11545 2975 11545 { lab=Vg}
N 2045 11440 2195 11440 { lab=VLX}
N 2085 11545 2235 11545 { lab=Vg}
N 2045 11500 2195 11500 { lab=Vout}
N 3580 11380 3580 11470 { lab=Vg}
N 455 11275 700 11275 { lab=VLX}
N 450 11440 700 11440 { lab=VLX}
N 450 11275 450 11440 { lab=VLX}
N 450 11275 455 11275 { lab=VLX}
N 570 11335 700 11335 { lab=Vout}
N 570 11335 570 11545 { lab=Vout}
N 700 11625 835 11625 { lab=VLX}
N 835 11625 985 11625 { lab=VLX}
N 985 11625 1145 11625 { lab=VLX}
N 1145 11625 1305 11625 { lab=VLX}
N 700 11685 835 11685 { lab=Vout}
N 835 11685 985 11685 { lab=Vout}
N 985 11685 1145 11685 { lab=Vout}
N 1145 11685 1305 11685 { lab=Vout}
N 740 11655 740 11730 { lab=Vg}
N 740 11730 875 11730 { lab=Vg}
N 875 11655 875 11730 { lab=Vg}
N 875 11730 1030 11730 { lab=Vg}
N 1345 11655 1345 11730 { lab=Vg}
N 1030 11730 1345 11730 { lab=Vg}
N 1025 11655 1025 11730 { lab=Vg}
N 1185 11655 1185 11730 { lab=Vg}
N 700 11625 700 11655 { lab=VLX}
N 835 11625 835 11655 { lab=VLX}
N 985 11625 985 11655 { lab=VLX}
N 1145 11625 1145 11655 { lab=VLX}
N 1305 11625 1305 11655 { lab=VLX}
N 1440 11625 1575 11625 { lab=VLX}
N 1575 11625 1725 11625 { lab=VLX}
N 1725 11625 1885 11625 { lab=VLX}
N 1885 11625 2045 11625 { lab=VLX}
N 1440 11685 1575 11685 { lab=Vout}
N 1575 11685 1725 11685 { lab=Vout}
N 1725 11685 1885 11685 { lab=Vout}
N 1885 11685 2045 11685 { lab=Vout}
N 1480 11655 1480 11730 { lab=Vg}
N 1480 11730 1615 11730 { lab=Vg}
N 1615 11655 1615 11730 { lab=Vg}
N 1615 11730 1770 11730 { lab=Vg}
N 2085 11655 2085 11730 { lab=Vg}
N 1770 11730 2085 11730 { lab=Vg}
N 1765 11655 1765 11730 { lab=Vg}
N 1925 11655 1925 11730 { lab=Vg}
N 1440 11625 1440 11655 { lab=VLX}
N 1575 11625 1575 11655 { lab=VLX}
N 1725 11625 1725 11655 { lab=VLX}
N 1885 11625 1885 11655 { lab=VLX}
N 2045 11625 2045 11655 { lab=VLX}
N 1305 11625 1440 11625 { lab=VLX}
N 1305 11685 1440 11685 { lab=Vout}
N 1345 11730 1480 11730 { lab=Vg}
N 2195 11625 2330 11625 { lab=VLX}
N 2330 11625 2480 11625 { lab=VLX}
N 2480 11625 2640 11625 { lab=VLX}
N 2640 11625 2800 11625 { lab=VLX}
N 2195 11685 2330 11685 { lab=Vout}
N 2330 11685 2480 11685 { lab=Vout}
N 2480 11685 2640 11685 { lab=Vout}
N 2640 11685 2800 11685 { lab=Vout}
N 2235 11655 2235 11730 { lab=Vg}
N 2235 11730 2370 11730 { lab=Vg}
N 2370 11655 2370 11730 { lab=Vg}
N 2370 11730 2525 11730 { lab=Vg}
N 2840 11655 2840 11730 { lab=Vg}
N 2525 11730 2840 11730 { lab=Vg}
N 2520 11655 2520 11730 { lab=Vg}
N 2680 11655 2680 11730 { lab=Vg}
N 2195 11625 2195 11655 { lab=VLX}
N 2330 11625 2330 11655 { lab=VLX}
N 2480 11625 2480 11655 { lab=VLX}
N 2640 11625 2640 11655 { lab=VLX}
N 2800 11625 2800 11655 { lab=VLX}
N 2935 11625 3070 11625 { lab=VLX}
N 3070 11625 3220 11625 { lab=VLX}
N 3220 11625 3380 11625 { lab=VLX}
N 3380 11625 3540 11625 { lab=VLX}
N 2935 11685 3070 11685 { lab=Vout}
N 3070 11685 3220 11685 { lab=Vout}
N 3220 11685 3380 11685 { lab=Vout}
N 3380 11685 3540 11685 { lab=Vout}
N 2975 11655 2975 11730 { lab=Vg}
N 2975 11730 3110 11730 { lab=Vg}
N 3110 11655 3110 11730 { lab=Vg}
N 3110 11730 3265 11730 { lab=Vg}
N 3580 11655 3580 11730 { lab=Vg}
N 3265 11730 3580 11730 { lab=Vg}
N 3260 11655 3260 11730 { lab=Vg}
N 3420 11655 3420 11730 { lab=Vg}
N 2935 11625 2935 11655 { lab=VLX}
N 3070 11625 3070 11655 { lab=VLX}
N 3220 11625 3220 11655 { lab=VLX}
N 3380 11625 3380 11655 { lab=VLX}
N 3540 11625 3540 11655 { lab=VLX}
N 2800 11625 2935 11625 { lab=VLX}
N 2800 11685 2935 11685 { lab=Vout}
N 2840 11730 2975 11730 { lab=Vg}
N 2045 11625 2195 11625 { lab=VLX}
N 2085 11730 2235 11730 { lab=Vg}
N 2045 11685 2195 11685 { lab=Vout}
N 700 11790 835 11790 { lab=VLX}
N 835 11790 985 11790 { lab=VLX}
N 985 11790 1145 11790 { lab=VLX}
N 1145 11790 1305 11790 { lab=VLX}
N 700 11850 835 11850 { lab=Vout}
N 835 11850 985 11850 { lab=Vout}
N 985 11850 1145 11850 { lab=Vout}
N 1145 11850 1305 11850 { lab=Vout}
N 740 11820 740 11895 { lab=Vg}
N 740 11895 875 11895 { lab=Vg}
N 875 11820 875 11895 { lab=Vg}
N 875 11895 1030 11895 { lab=Vg}
N 1345 11820 1345 11895 { lab=Vg}
N 1030 11895 1345 11895 { lab=Vg}
N 1025 11820 1025 11895 { lab=Vg}
N 1185 11820 1185 11895 { lab=Vg}
N 700 11790 700 11820 { lab=VLX}
N 835 11790 835 11820 { lab=VLX}
N 985 11790 985 11820 { lab=VLX}
N 1145 11790 1145 11820 { lab=VLX}
N 1305 11790 1305 11820 { lab=VLX}
N 1440 11790 1575 11790 { lab=VLX}
N 1575 11790 1725 11790 { lab=VLX}
N 1725 11790 1885 11790 { lab=VLX}
N 1885 11790 2045 11790 { lab=VLX}
N 1440 11850 1575 11850 { lab=Vout}
N 1575 11850 1725 11850 { lab=Vout}
N 1725 11850 1885 11850 { lab=Vout}
N 1885 11850 2045 11850 { lab=Vout}
N 1480 11820 1480 11895 { lab=Vg}
N 1480 11895 1615 11895 { lab=Vg}
N 1615 11820 1615 11895 { lab=Vg}
N 1615 11895 1770 11895 { lab=Vg}
N 2085 11820 2085 11895 { lab=Vg}
N 1770 11895 2085 11895 { lab=Vg}
N 1765 11820 1765 11895 { lab=Vg}
N 1925 11820 1925 11895 { lab=Vg}
N 1440 11790 1440 11820 { lab=VLX}
N 1575 11790 1575 11820 { lab=VLX}
N 1725 11790 1725 11820 { lab=VLX}
N 1885 11790 1885 11820 { lab=VLX}
N 2045 11790 2045 11820 { lab=VLX}
N 1305 11790 1440 11790 { lab=VLX}
N 1305 11850 1440 11850 { lab=Vout}
N 1345 11895 1480 11895 { lab=Vg}
N 2195 11790 2330 11790 { lab=VLX}
N 2330 11790 2480 11790 { lab=VLX}
N 2480 11790 2640 11790 { lab=VLX}
N 2640 11790 2800 11790 { lab=VLX}
N 2195 11850 2330 11850 { lab=Vout}
N 2330 11850 2480 11850 { lab=Vout}
N 2480 11850 2640 11850 { lab=Vout}
N 2640 11850 2800 11850 { lab=Vout}
N 2235 11820 2235 11895 { lab=Vg}
N 2235 11895 2370 11895 { lab=Vg}
N 2370 11820 2370 11895 { lab=Vg}
N 2370 11895 2525 11895 { lab=Vg}
N 2840 11820 2840 11895 { lab=Vg}
N 2525 11895 2840 11895 { lab=Vg}
N 2520 11820 2520 11895 { lab=Vg}
N 2680 11820 2680 11895 { lab=Vg}
N 2195 11790 2195 11820 { lab=VLX}
N 2330 11790 2330 11820 { lab=VLX}
N 2480 11790 2480 11820 { lab=VLX}
N 2640 11790 2640 11820 { lab=VLX}
N 2800 11790 2800 11820 { lab=VLX}
N 2935 11790 3070 11790 { lab=VLX}
N 3070 11790 3220 11790 { lab=VLX}
N 3220 11790 3380 11790 { lab=VLX}
N 3380 11790 3540 11790 { lab=VLX}
N 2935 11850 3070 11850 { lab=Vout}
N 3070 11850 3220 11850 { lab=Vout}
N 3220 11850 3380 11850 { lab=Vout}
N 3380 11850 3540 11850 { lab=Vout}
N 2975 11820 2975 11895 { lab=Vg}
N 2975 11895 3110 11895 { lab=Vg}
N 3110 11820 3110 11895 { lab=Vg}
N 3110 11895 3265 11895 { lab=Vg}
N 3580 11820 3580 11895 { lab=Vg}
N 3265 11895 3580 11895 { lab=Vg}
N 3260 11820 3260 11895 { lab=Vg}
N 3420 11820 3420 11895 { lab=Vg}
N 2935 11790 2935 11820 { lab=VLX}
N 3070 11790 3070 11820 { lab=VLX}
N 3220 11790 3220 11820 { lab=VLX}
N 3380 11790 3380 11820 { lab=VLX}
N 3540 11790 3540 11820 { lab=VLX}
N 2800 11790 2935 11790 { lab=VLX}
N 2800 11850 2935 11850 { lab=Vout}
N 2840 11895 2975 11895 { lab=Vg}
N 2045 11790 2195 11790 { lab=VLX}
N 2085 11895 2235 11895 { lab=Vg}
N 2045 11850 2195 11850 { lab=Vout}
N 3580 11730 3580 11820 { lab=Vg}
N 455 11625 700 11625 { lab=VLX}
N 450 11790 700 11790 { lab=VLX}
N 450 11625 450 11790 { lab=VLX}
N 450 11625 455 11625 { lab=VLX}
N 570 11685 700 11685 { lab=Vout}
N 570 11685 570 11895 { lab=Vout}
N 450 11440 450 11630 { lab=VLX}
N 570 11540 570 11690 { lab=Vout}
N 3580 11540 3580 11660 { lab=Vg}
N 450 11120 450 11280 { lab=VLX}
N 570 11220 570 11340 { lab=Vout}
N 3580 11230 3580 11300 { lab=Vg}
N 3580 11220 3580 11230 { lab=Vg}
N 3580 10470 3580 10640 { lab=Vg}
N 570 10470 570 10680 { lab=Vout}
N 450 10370 450 10610 { lab=VLX}
N 700 12045 835 12045 { lab=VLX}
N 835 12045 985 12045 { lab=VLX}
N 985 12045 1145 12045 { lab=VLX}
N 1145 12045 1305 12045 { lab=VLX}
N 700 12105 835 12105 { lab=Vout}
N 835 12105 985 12105 { lab=Vout}
N 985 12105 1145 12105 { lab=Vout}
N 1145 12105 1305 12105 { lab=Vout}
N 740 12075 740 12150 { lab=Vg}
N 740 12150 875 12150 { lab=Vg}
N 875 12075 875 12150 { lab=Vg}
N 875 12150 1030 12150 { lab=Vg}
N 1345 12075 1345 12150 { lab=Vg}
N 1030 12150 1345 12150 { lab=Vg}
N 1025 12075 1025 12150 { lab=Vg}
N 1185 12075 1185 12150 { lab=Vg}
N 700 12045 700 12075 { lab=VLX}
N 835 12045 835 12075 { lab=VLX}
N 985 12045 985 12075 { lab=VLX}
N 1145 12045 1145 12075 { lab=VLX}
N 1305 12045 1305 12075 { lab=VLX}
N 1440 12045 1575 12045 { lab=VLX}
N 1575 12045 1725 12045 { lab=VLX}
N 1725 12045 1885 12045 { lab=VLX}
N 1885 12045 2045 12045 { lab=VLX}
N 1440 12105 1575 12105 { lab=Vout}
N 1575 12105 1725 12105 { lab=Vout}
N 1725 12105 1885 12105 { lab=Vout}
N 1885 12105 2045 12105 { lab=Vout}
N 1480 12075 1480 12150 { lab=Vg}
N 1480 12150 1615 12150 { lab=Vg}
N 1615 12075 1615 12150 { lab=Vg}
N 1615 12150 1770 12150 { lab=Vg}
N 2085 12075 2085 12150 { lab=Vg}
N 1770 12150 2085 12150 { lab=Vg}
N 1765 12075 1765 12150 { lab=Vg}
N 1925 12075 1925 12150 { lab=Vg}
N 1440 12045 1440 12075 { lab=VLX}
N 1575 12045 1575 12075 { lab=VLX}
N 1725 12045 1725 12075 { lab=VLX}
N 1885 12045 1885 12075 { lab=VLX}
N 2045 12045 2045 12075 { lab=VLX}
N 1305 12045 1440 12045 { lab=VLX}
N 1305 12105 1440 12105 { lab=Vout}
N 1345 12150 1480 12150 { lab=Vg}
N 2195 12045 2330 12045 { lab=VLX}
N 2330 12045 2480 12045 { lab=VLX}
N 2480 12045 2640 12045 { lab=VLX}
N 2640 12045 2800 12045 { lab=VLX}
N 2195 12105 2330 12105 { lab=Vout}
N 2330 12105 2480 12105 { lab=Vout}
N 2480 12105 2640 12105 { lab=Vout}
N 2640 12105 2800 12105 { lab=Vout}
N 2235 12075 2235 12150 { lab=Vg}
N 2235 12150 2370 12150 { lab=Vg}
N 2370 12075 2370 12150 { lab=Vg}
N 2370 12150 2525 12150 { lab=Vg}
N 2840 12075 2840 12150 { lab=Vg}
N 2525 12150 2840 12150 { lab=Vg}
N 2520 12075 2520 12150 { lab=Vg}
N 2680 12075 2680 12150 { lab=Vg}
N 2195 12045 2195 12075 { lab=VLX}
N 2330 12045 2330 12075 { lab=VLX}
N 2480 12045 2480 12075 { lab=VLX}
N 2640 12045 2640 12075 { lab=VLX}
N 2800 12045 2800 12075 { lab=VLX}
N 2935 12045 3070 12045 { lab=VLX}
N 3070 12045 3220 12045 { lab=VLX}
N 3220 12045 3380 12045 { lab=VLX}
N 3380 12045 3540 12045 { lab=VLX}
N 2935 12105 3070 12105 { lab=Vout}
N 3070 12105 3220 12105 { lab=Vout}
N 3220 12105 3380 12105 { lab=Vout}
N 3380 12105 3540 12105 { lab=Vout}
N 2975 12075 2975 12150 { lab=Vg}
N 2975 12150 3110 12150 { lab=Vg}
N 3110 12075 3110 12150 { lab=Vg}
N 3110 12150 3265 12150 { lab=Vg}
N 3580 12075 3580 12150 { lab=Vg}
N 3265 12150 3580 12150 { lab=Vg}
N 3260 12075 3260 12150 { lab=Vg}
N 3420 12075 3420 12150 { lab=Vg}
N 2935 12045 2935 12075 { lab=VLX}
N 3070 12045 3070 12075 { lab=VLX}
N 3220 12045 3220 12075 { lab=VLX}
N 3380 12045 3380 12075 { lab=VLX}
N 3540 12045 3540 12075 { lab=VLX}
N 2800 12045 2935 12045 { lab=VLX}
N 2800 12105 2935 12105 { lab=Vout}
N 2840 12150 2975 12150 { lab=Vg}
N 2045 12045 2195 12045 { lab=VLX}
N 2085 12150 2235 12150 { lab=Vg}
N 2045 12105 2195 12105 { lab=Vout}
N 700 12210 835 12210 { lab=VLX}
N 835 12210 985 12210 { lab=VLX}
N 985 12210 1145 12210 { lab=VLX}
N 1145 12210 1305 12210 { lab=VLX}
N 700 12270 835 12270 { lab=Vout}
N 835 12270 985 12270 { lab=Vout}
N 985 12270 1145 12270 { lab=Vout}
N 1145 12270 1305 12270 { lab=Vout}
N 740 12240 740 12315 { lab=Vg}
N 740 12315 875 12315 { lab=Vg}
N 875 12240 875 12315 { lab=Vg}
N 875 12315 1030 12315 { lab=Vg}
N 1345 12240 1345 12315 { lab=Vg}
N 1030 12315 1345 12315 { lab=Vg}
N 1025 12240 1025 12315 { lab=Vg}
N 1185 12240 1185 12315 { lab=Vg}
N 700 12210 700 12240 { lab=VLX}
N 835 12210 835 12240 { lab=VLX}
N 985 12210 985 12240 { lab=VLX}
N 1145 12210 1145 12240 { lab=VLX}
N 1305 12210 1305 12240 { lab=VLX}
N 1440 12210 1575 12210 { lab=VLX}
N 1575 12210 1725 12210 { lab=VLX}
N 1725 12210 1885 12210 { lab=VLX}
N 1885 12210 2045 12210 { lab=VLX}
N 1440 12270 1575 12270 { lab=Vout}
N 1575 12270 1725 12270 { lab=Vout}
N 1725 12270 1885 12270 { lab=Vout}
N 1885 12270 2045 12270 { lab=Vout}
N 1480 12240 1480 12315 { lab=Vg}
N 1480 12315 1615 12315 { lab=Vg}
N 1615 12240 1615 12315 { lab=Vg}
N 1615 12315 1770 12315 { lab=Vg}
N 2085 12240 2085 12315 { lab=Vg}
N 1770 12315 2085 12315 { lab=Vg}
N 1765 12240 1765 12315 { lab=Vg}
N 1925 12240 1925 12315 { lab=Vg}
N 1440 12210 1440 12240 { lab=VLX}
N 1575 12210 1575 12240 { lab=VLX}
N 1725 12210 1725 12240 { lab=VLX}
N 1885 12210 1885 12240 { lab=VLX}
N 2045 12210 2045 12240 { lab=VLX}
N 1305 12210 1440 12210 { lab=VLX}
N 1305 12270 1440 12270 { lab=Vout}
N 1345 12315 1480 12315 { lab=Vg}
N 2195 12210 2330 12210 { lab=VLX}
N 2330 12210 2480 12210 { lab=VLX}
N 2480 12210 2640 12210 { lab=VLX}
N 2640 12210 2800 12210 { lab=VLX}
N 2195 12270 2330 12270 { lab=Vout}
N 2330 12270 2480 12270 { lab=Vout}
N 2480 12270 2640 12270 { lab=Vout}
N 2640 12270 2800 12270 { lab=Vout}
N 2235 12240 2235 12315 { lab=Vg}
N 2235 12315 2370 12315 { lab=Vg}
N 2370 12240 2370 12315 { lab=Vg}
N 2370 12315 2525 12315 { lab=Vg}
N 2840 12240 2840 12315 { lab=Vg}
N 2525 12315 2840 12315 { lab=Vg}
N 2520 12240 2520 12315 { lab=Vg}
N 2680 12240 2680 12315 { lab=Vg}
N 2195 12210 2195 12240 { lab=VLX}
N 2330 12210 2330 12240 { lab=VLX}
N 2480 12210 2480 12240 { lab=VLX}
N 2640 12210 2640 12240 { lab=VLX}
N 2800 12210 2800 12240 { lab=VLX}
N 2935 12210 3070 12210 { lab=VLX}
N 3070 12210 3220 12210 { lab=VLX}
N 3220 12210 3380 12210 { lab=VLX}
N 3380 12210 3540 12210 { lab=VLX}
N 2935 12270 3070 12270 { lab=Vout}
N 3070 12270 3220 12270 { lab=Vout}
N 3220 12270 3380 12270 { lab=Vout}
N 3380 12270 3540 12270 { lab=Vout}
N 2975 12240 2975 12315 { lab=Vg}
N 2975 12315 3110 12315 { lab=Vg}
N 3110 12240 3110 12315 { lab=Vg}
N 3110 12315 3265 12315 { lab=Vg}
N 3580 12240 3580 12315 { lab=Vg}
N 3265 12315 3580 12315 { lab=Vg}
N 3260 12240 3260 12315 { lab=Vg}
N 3420 12240 3420 12315 { lab=Vg}
N 2935 12210 2935 12240 { lab=VLX}
N 3070 12210 3070 12240 { lab=VLX}
N 3220 12210 3220 12240 { lab=VLX}
N 3380 12210 3380 12240 { lab=VLX}
N 3540 12210 3540 12240 { lab=VLX}
N 2800 12210 2935 12210 { lab=VLX}
N 2800 12270 2935 12270 { lab=Vout}
N 2840 12315 2975 12315 { lab=Vg}
N 2045 12210 2195 12210 { lab=VLX}
N 2085 12315 2235 12315 { lab=Vg}
N 2045 12270 2195 12270 { lab=Vout}
N 3580 12150 3580 12240 { lab=Vg}
N 455 12045 700 12045 { lab=VLX}
N 450 12210 700 12210 { lab=VLX}
N 450 12045 450 12210 { lab=VLX}
N 450 12045 455 12045 { lab=VLX}
N 570 12105 700 12105 { lab=Vout}
N 570 12105 570 12315 { lab=Vout}
N 700 12395 835 12395 { lab=VLX}
N 835 12395 985 12395 { lab=VLX}
N 985 12395 1145 12395 { lab=VLX}
N 1145 12395 1305 12395 { lab=VLX}
N 700 12455 835 12455 { lab=Vout}
N 835 12455 985 12455 { lab=Vout}
N 985 12455 1145 12455 { lab=Vout}
N 1145 12455 1305 12455 { lab=Vout}
N 740 12425 740 12500 { lab=Vg}
N 740 12500 875 12500 { lab=Vg}
N 875 12425 875 12500 { lab=Vg}
N 875 12500 1030 12500 { lab=Vg}
N 1345 12425 1345 12500 { lab=Vg}
N 1030 12500 1345 12500 { lab=Vg}
N 1025 12425 1025 12500 { lab=Vg}
N 1185 12425 1185 12500 { lab=Vg}
N 700 12395 700 12425 { lab=VLX}
N 835 12395 835 12425 { lab=VLX}
N 985 12395 985 12425 { lab=VLX}
N 1145 12395 1145 12425 { lab=VLX}
N 1305 12395 1305 12425 { lab=VLX}
N 1440 12395 1575 12395 { lab=VLX}
N 1575 12395 1725 12395 { lab=VLX}
N 1725 12395 1885 12395 { lab=VLX}
N 1885 12395 2045 12395 { lab=VLX}
N 1440 12455 1575 12455 { lab=Vout}
N 1575 12455 1725 12455 { lab=Vout}
N 1725 12455 1885 12455 { lab=Vout}
N 1885 12455 2045 12455 { lab=Vout}
N 1480 12425 1480 12500 { lab=Vg}
N 1480 12500 1615 12500 { lab=Vg}
N 1615 12425 1615 12500 { lab=Vg}
N 1615 12500 1770 12500 { lab=Vg}
N 2085 12425 2085 12500 { lab=Vg}
N 1770 12500 2085 12500 { lab=Vg}
N 1765 12425 1765 12500 { lab=Vg}
N 1925 12425 1925 12500 { lab=Vg}
N 1440 12395 1440 12425 { lab=VLX}
N 1575 12395 1575 12425 { lab=VLX}
N 1725 12395 1725 12425 { lab=VLX}
N 1885 12395 1885 12425 { lab=VLX}
N 2045 12395 2045 12425 { lab=VLX}
N 1305 12395 1440 12395 { lab=VLX}
N 1305 12455 1440 12455 { lab=Vout}
N 1345 12500 1480 12500 { lab=Vg}
N 2195 12395 2330 12395 { lab=VLX}
N 2330 12395 2480 12395 { lab=VLX}
N 2480 12395 2640 12395 { lab=VLX}
N 2640 12395 2800 12395 { lab=VLX}
N 2195 12455 2330 12455 { lab=Vout}
N 2330 12455 2480 12455 { lab=Vout}
N 2480 12455 2640 12455 { lab=Vout}
N 2640 12455 2800 12455 { lab=Vout}
N 2235 12425 2235 12500 { lab=Vg}
N 2235 12500 2370 12500 { lab=Vg}
N 2370 12425 2370 12500 { lab=Vg}
N 2370 12500 2525 12500 { lab=Vg}
N 2840 12425 2840 12500 { lab=Vg}
N 2525 12500 2840 12500 { lab=Vg}
N 2520 12425 2520 12500 { lab=Vg}
N 2680 12425 2680 12500 { lab=Vg}
N 2195 12395 2195 12425 { lab=VLX}
N 2330 12395 2330 12425 { lab=VLX}
N 2480 12395 2480 12425 { lab=VLX}
N 2640 12395 2640 12425 { lab=VLX}
N 2800 12395 2800 12425 { lab=VLX}
N 2935 12395 3070 12395 { lab=VLX}
N 3070 12395 3220 12395 { lab=VLX}
N 3220 12395 3380 12395 { lab=VLX}
N 3380 12395 3540 12395 { lab=VLX}
N 2935 12455 3070 12455 { lab=Vout}
N 3070 12455 3220 12455 { lab=Vout}
N 3220 12455 3380 12455 { lab=Vout}
N 3380 12455 3540 12455 { lab=Vout}
N 2975 12425 2975 12500 { lab=Vg}
N 2975 12500 3110 12500 { lab=Vg}
N 3110 12425 3110 12500 { lab=Vg}
N 3110 12500 3265 12500 { lab=Vg}
N 3580 12425 3580 12500 { lab=Vg}
N 3265 12500 3580 12500 { lab=Vg}
N 3260 12425 3260 12500 { lab=Vg}
N 3420 12425 3420 12500 { lab=Vg}
N 2935 12395 2935 12425 { lab=VLX}
N 3070 12395 3070 12425 { lab=VLX}
N 3220 12395 3220 12425 { lab=VLX}
N 3380 12395 3380 12425 { lab=VLX}
N 3540 12395 3540 12425 { lab=VLX}
N 2800 12395 2935 12395 { lab=VLX}
N 2800 12455 2935 12455 { lab=Vout}
N 2840 12500 2975 12500 { lab=Vg}
N 2045 12395 2195 12395 { lab=VLX}
N 2085 12500 2235 12500 { lab=Vg}
N 2045 12455 2195 12455 { lab=Vout}
N 700 12560 835 12560 { lab=VLX}
N 835 12560 985 12560 { lab=VLX}
N 985 12560 1145 12560 { lab=VLX}
N 1145 12560 1305 12560 { lab=VLX}
N 700 12620 835 12620 { lab=Vout}
N 835 12620 985 12620 { lab=Vout}
N 985 12620 1145 12620 { lab=Vout}
N 1145 12620 1305 12620 { lab=Vout}
N 740 12590 740 12665 { lab=Vg}
N 740 12665 875 12665 { lab=Vg}
N 875 12590 875 12665 { lab=Vg}
N 875 12665 1030 12665 { lab=Vg}
N 1345 12590 1345 12665 { lab=Vg}
N 1030 12665 1345 12665 { lab=Vg}
N 1025 12590 1025 12665 { lab=Vg}
N 1185 12590 1185 12665 { lab=Vg}
N 700 12560 700 12590 { lab=VLX}
N 835 12560 835 12590 { lab=VLX}
N 985 12560 985 12590 { lab=VLX}
N 1145 12560 1145 12590 { lab=VLX}
N 1305 12560 1305 12590 { lab=VLX}
N 1440 12560 1575 12560 { lab=VLX}
N 1575 12560 1725 12560 { lab=VLX}
N 1725 12560 1885 12560 { lab=VLX}
N 1885 12560 2045 12560 { lab=VLX}
N 1440 12620 1575 12620 { lab=Vout}
N 1575 12620 1725 12620 { lab=Vout}
N 1725 12620 1885 12620 { lab=Vout}
N 1885 12620 2045 12620 { lab=Vout}
N 1480 12590 1480 12665 { lab=Vg}
N 1480 12665 1615 12665 { lab=Vg}
N 1615 12590 1615 12665 { lab=Vg}
N 1615 12665 1770 12665 { lab=Vg}
N 2085 12590 2085 12665 { lab=Vg}
N 1770 12665 2085 12665 { lab=Vg}
N 1765 12590 1765 12665 { lab=Vg}
N 1925 12590 1925 12665 { lab=Vg}
N 1440 12560 1440 12590 { lab=VLX}
N 1575 12560 1575 12590 { lab=VLX}
N 1725 12560 1725 12590 { lab=VLX}
N 1885 12560 1885 12590 { lab=VLX}
N 2045 12560 2045 12590 { lab=VLX}
N 1305 12560 1440 12560 { lab=VLX}
N 1305 12620 1440 12620 { lab=Vout}
N 1345 12665 1480 12665 { lab=Vg}
N 2195 12560 2330 12560 { lab=VLX}
N 2330 12560 2480 12560 { lab=VLX}
N 2480 12560 2640 12560 { lab=VLX}
N 2640 12560 2800 12560 { lab=VLX}
N 2195 12620 2330 12620 { lab=Vout}
N 2330 12620 2480 12620 { lab=Vout}
N 2480 12620 2640 12620 { lab=Vout}
N 2640 12620 2800 12620 { lab=Vout}
N 2235 12590 2235 12665 { lab=Vg}
N 2235 12665 2370 12665 { lab=Vg}
N 2370 12590 2370 12665 { lab=Vg}
N 2370 12665 2525 12665 { lab=Vg}
N 2840 12590 2840 12665 { lab=Vg}
N 2525 12665 2840 12665 { lab=Vg}
N 2520 12590 2520 12665 { lab=Vg}
N 2680 12590 2680 12665 { lab=Vg}
N 2195 12560 2195 12590 { lab=VLX}
N 2330 12560 2330 12590 { lab=VLX}
N 2480 12560 2480 12590 { lab=VLX}
N 2640 12560 2640 12590 { lab=VLX}
N 2800 12560 2800 12590 { lab=VLX}
N 2935 12560 3070 12560 { lab=VLX}
N 3070 12560 3220 12560 { lab=VLX}
N 3220 12560 3380 12560 { lab=VLX}
N 3380 12560 3540 12560 { lab=VLX}
N 2935 12620 3070 12620 { lab=Vout}
N 3070 12620 3220 12620 { lab=Vout}
N 3220 12620 3380 12620 { lab=Vout}
N 3380 12620 3540 12620 { lab=Vout}
N 2975 12590 2975 12665 { lab=Vg}
N 2975 12665 3110 12665 { lab=Vg}
N 3110 12590 3110 12665 { lab=Vg}
N 3110 12665 3265 12665 { lab=Vg}
N 3580 12590 3580 12665 { lab=Vg}
N 3265 12665 3580 12665 { lab=Vg}
N 3260 12590 3260 12665 { lab=Vg}
N 3420 12590 3420 12665 { lab=Vg}
N 2935 12560 2935 12590 { lab=VLX}
N 3070 12560 3070 12590 { lab=VLX}
N 3220 12560 3220 12590 { lab=VLX}
N 3380 12560 3380 12590 { lab=VLX}
N 3540 12560 3540 12590 { lab=VLX}
N 2800 12560 2935 12560 { lab=VLX}
N 2800 12620 2935 12620 { lab=Vout}
N 2840 12665 2975 12665 { lab=Vg}
N 2045 12560 2195 12560 { lab=VLX}
N 2085 12665 2235 12665 { lab=Vg}
N 2045 12620 2195 12620 { lab=Vout}
N 3580 12500 3580 12590 { lab=Vg}
N 455 12395 700 12395 { lab=VLX}
N 450 12560 700 12560 { lab=VLX}
N 450 12395 450 12560 { lab=VLX}
N 450 12395 455 12395 { lab=VLX}
N 570 12455 700 12455 { lab=Vout}
N 570 12455 570 12665 { lab=Vout}
N 450 12210 450 12400 { lab=VLX}
N 570 12310 570 12460 { lab=Vout}
N 3580 12310 3580 12430 { lab=Vg}
N 700 12715 835 12715 { lab=VLX}
N 835 12715 985 12715 { lab=VLX}
N 985 12715 1145 12715 { lab=VLX}
N 1145 12715 1305 12715 { lab=VLX}
N 700 12775 835 12775 { lab=Vout}
N 835 12775 985 12775 { lab=Vout}
N 985 12775 1145 12775 { lab=Vout}
N 1145 12775 1305 12775 { lab=Vout}
N 740 12745 740 12820 { lab=Vg}
N 740 12820 875 12820 { lab=Vg}
N 875 12745 875 12820 { lab=Vg}
N 875 12820 1030 12820 { lab=Vg}
N 1345 12745 1345 12820 { lab=Vg}
N 1030 12820 1345 12820 { lab=Vg}
N 1025 12745 1025 12820 { lab=Vg}
N 1185 12745 1185 12820 { lab=Vg}
N 700 12715 700 12745 { lab=VLX}
N 835 12715 835 12745 { lab=VLX}
N 985 12715 985 12745 { lab=VLX}
N 1145 12715 1145 12745 { lab=VLX}
N 1305 12715 1305 12745 { lab=VLX}
N 1440 12715 1575 12715 { lab=VLX}
N 1575 12715 1725 12715 { lab=VLX}
N 1725 12715 1885 12715 { lab=VLX}
N 1885 12715 2045 12715 { lab=VLX}
N 1440 12775 1575 12775 { lab=Vout}
N 1575 12775 1725 12775 { lab=Vout}
N 1725 12775 1885 12775 { lab=Vout}
N 1885 12775 2045 12775 { lab=Vout}
N 1480 12745 1480 12820 { lab=Vg}
N 1480 12820 1615 12820 { lab=Vg}
N 1615 12745 1615 12820 { lab=Vg}
N 1615 12820 1770 12820 { lab=Vg}
N 2085 12745 2085 12820 { lab=Vg}
N 1770 12820 2085 12820 { lab=Vg}
N 1765 12745 1765 12820 { lab=Vg}
N 1925 12745 1925 12820 { lab=Vg}
N 1440 12715 1440 12745 { lab=VLX}
N 1575 12715 1575 12745 { lab=VLX}
N 1725 12715 1725 12745 { lab=VLX}
N 1885 12715 1885 12745 { lab=VLX}
N 2045 12715 2045 12745 { lab=VLX}
N 1305 12715 1440 12715 { lab=VLX}
N 1305 12775 1440 12775 { lab=Vout}
N 1345 12820 1480 12820 { lab=Vg}
N 2195 12715 2330 12715 { lab=VLX}
N 2330 12715 2480 12715 { lab=VLX}
N 2480 12715 2640 12715 { lab=VLX}
N 2640 12715 2800 12715 { lab=VLX}
N 2195 12775 2330 12775 { lab=Vout}
N 2330 12775 2480 12775 { lab=Vout}
N 2480 12775 2640 12775 { lab=Vout}
N 2640 12775 2800 12775 { lab=Vout}
N 2235 12745 2235 12820 { lab=Vg}
N 2235 12820 2370 12820 { lab=Vg}
N 2370 12745 2370 12820 { lab=Vg}
N 2370 12820 2525 12820 { lab=Vg}
N 2840 12745 2840 12820 { lab=Vg}
N 2525 12820 2840 12820 { lab=Vg}
N 2520 12745 2520 12820 { lab=Vg}
N 2680 12745 2680 12820 { lab=Vg}
N 2195 12715 2195 12745 { lab=VLX}
N 2330 12715 2330 12745 { lab=VLX}
N 2480 12715 2480 12745 { lab=VLX}
N 2640 12715 2640 12745 { lab=VLX}
N 2800 12715 2800 12745 { lab=VLX}
N 2935 12715 3070 12715 { lab=VLX}
N 3070 12715 3220 12715 { lab=VLX}
N 3220 12715 3380 12715 { lab=VLX}
N 3380 12715 3540 12715 { lab=VLX}
N 2935 12775 3070 12775 { lab=Vout}
N 3070 12775 3220 12775 { lab=Vout}
N 3220 12775 3380 12775 { lab=Vout}
N 3380 12775 3540 12775 { lab=Vout}
N 2975 12745 2975 12820 { lab=Vg}
N 2975 12820 3110 12820 { lab=Vg}
N 3110 12745 3110 12820 { lab=Vg}
N 3110 12820 3265 12820 { lab=Vg}
N 3580 12745 3580 12820 { lab=Vg}
N 3265 12820 3580 12820 { lab=Vg}
N 3260 12745 3260 12820 { lab=Vg}
N 3420 12745 3420 12820 { lab=Vg}
N 2935 12715 2935 12745 { lab=VLX}
N 3070 12715 3070 12745 { lab=VLX}
N 3220 12715 3220 12745 { lab=VLX}
N 3380 12715 3380 12745 { lab=VLX}
N 3540 12715 3540 12745 { lab=VLX}
N 2800 12715 2935 12715 { lab=VLX}
N 2800 12775 2935 12775 { lab=Vout}
N 2840 12820 2975 12820 { lab=Vg}
N 2045 12715 2195 12715 { lab=VLX}
N 2085 12820 2235 12820 { lab=Vg}
N 2045 12775 2195 12775 { lab=Vout}
N 700 12880 835 12880 { lab=VLX}
N 835 12880 985 12880 { lab=VLX}
N 985 12880 1145 12880 { lab=VLX}
N 1145 12880 1305 12880 { lab=VLX}
N 700 12940 835 12940 { lab=Vout}
N 835 12940 985 12940 { lab=Vout}
N 985 12940 1145 12940 { lab=Vout}
N 1145 12940 1305 12940 { lab=Vout}
N 740 12910 740 12985 { lab=Vg}
N 740 12985 875 12985 { lab=Vg}
N 875 12910 875 12985 { lab=Vg}
N 875 12985 1030 12985 { lab=Vg}
N 1345 12910 1345 12985 { lab=Vg}
N 1030 12985 1345 12985 { lab=Vg}
N 1025 12910 1025 12985 { lab=Vg}
N 1185 12910 1185 12985 { lab=Vg}
N 700 12880 700 12910 { lab=VLX}
N 835 12880 835 12910 { lab=VLX}
N 985 12880 985 12910 { lab=VLX}
N 1145 12880 1145 12910 { lab=VLX}
N 1305 12880 1305 12910 { lab=VLX}
N 1440 12880 1575 12880 { lab=VLX}
N 1575 12880 1725 12880 { lab=VLX}
N 1725 12880 1885 12880 { lab=VLX}
N 1885 12880 2045 12880 { lab=VLX}
N 1440 12940 1575 12940 { lab=Vout}
N 1575 12940 1725 12940 { lab=Vout}
N 1725 12940 1885 12940 { lab=Vout}
N 1885 12940 2045 12940 { lab=Vout}
N 1480 12910 1480 12985 { lab=Vg}
N 1480 12985 1615 12985 { lab=Vg}
N 1615 12910 1615 12985 { lab=Vg}
N 1615 12985 1770 12985 { lab=Vg}
N 2085 12910 2085 12985 { lab=Vg}
N 1770 12985 2085 12985 { lab=Vg}
N 1765 12910 1765 12985 { lab=Vg}
N 1925 12910 1925 12985 { lab=Vg}
N 1440 12880 1440 12910 { lab=VLX}
N 1575 12880 1575 12910 { lab=VLX}
N 1725 12880 1725 12910 { lab=VLX}
N 1885 12880 1885 12910 { lab=VLX}
N 2045 12880 2045 12910 { lab=VLX}
N 1305 12880 1440 12880 { lab=VLX}
N 1305 12940 1440 12940 { lab=Vout}
N 1345 12985 1480 12985 { lab=Vg}
N 2195 12880 2330 12880 { lab=VLX}
N 2330 12880 2480 12880 { lab=VLX}
N 2480 12880 2640 12880 { lab=VLX}
N 2640 12880 2800 12880 { lab=VLX}
N 2195 12940 2330 12940 { lab=Vout}
N 2330 12940 2480 12940 { lab=Vout}
N 2480 12940 2640 12940 { lab=Vout}
N 2640 12940 2800 12940 { lab=Vout}
N 2235 12910 2235 12985 { lab=Vg}
N 2235 12985 2370 12985 { lab=Vg}
N 2370 12910 2370 12985 { lab=Vg}
N 2370 12985 2525 12985 { lab=Vg}
N 2840 12910 2840 12985 { lab=Vg}
N 2525 12985 2840 12985 { lab=Vg}
N 2520 12910 2520 12985 { lab=Vg}
N 2680 12910 2680 12985 { lab=Vg}
N 2195 12880 2195 12910 { lab=VLX}
N 2330 12880 2330 12910 { lab=VLX}
N 2480 12880 2480 12910 { lab=VLX}
N 2640 12880 2640 12910 { lab=VLX}
N 2800 12880 2800 12910 { lab=VLX}
N 2935 12880 3070 12880 { lab=VLX}
N 3070 12880 3220 12880 { lab=VLX}
N 3220 12880 3380 12880 { lab=VLX}
N 3380 12880 3540 12880 { lab=VLX}
N 2935 12940 3070 12940 { lab=Vout}
N 3070 12940 3220 12940 { lab=Vout}
N 3220 12940 3380 12940 { lab=Vout}
N 3380 12940 3540 12940 { lab=Vout}
N 2975 12910 2975 12985 { lab=Vg}
N 2975 12985 3110 12985 { lab=Vg}
N 3110 12910 3110 12985 { lab=Vg}
N 3110 12985 3265 12985 { lab=Vg}
N 3580 12910 3580 12985 { lab=Vg}
N 3265 12985 3580 12985 { lab=Vg}
N 3260 12910 3260 12985 { lab=Vg}
N 3420 12910 3420 12985 { lab=Vg}
N 2935 12880 2935 12910 { lab=VLX}
N 3070 12880 3070 12910 { lab=VLX}
N 3220 12880 3220 12910 { lab=VLX}
N 3380 12880 3380 12910 { lab=VLX}
N 3540 12880 3540 12910 { lab=VLX}
N 2800 12880 2935 12880 { lab=VLX}
N 2800 12940 2935 12940 { lab=Vout}
N 2840 12985 2975 12985 { lab=Vg}
N 2045 12880 2195 12880 { lab=VLX}
N 2085 12985 2235 12985 { lab=Vg}
N 2045 12940 2195 12940 { lab=Vout}
N 3580 12820 3580 12910 { lab=Vg}
N 455 12715 700 12715 { lab=VLX}
N 450 12880 700 12880 { lab=VLX}
N 450 12715 450 12880 { lab=VLX}
N 450 12715 455 12715 { lab=VLX}
N 570 12775 700 12775 { lab=Vout}
N 570 12775 570 12985 { lab=Vout}
N 700 13065 835 13065 { lab=VLX}
N 835 13065 985 13065 { lab=VLX}
N 985 13065 1145 13065 { lab=VLX}
N 1145 13065 1305 13065 { lab=VLX}
N 700 13125 835 13125 { lab=Vout}
N 835 13125 985 13125 { lab=Vout}
N 985 13125 1145 13125 { lab=Vout}
N 1145 13125 1305 13125 { lab=Vout}
N 740 13095 740 13170 { lab=Vg}
N 740 13170 875 13170 { lab=Vg}
N 875 13095 875 13170 { lab=Vg}
N 875 13170 1030 13170 { lab=Vg}
N 1345 13095 1345 13170 { lab=Vg}
N 1030 13170 1345 13170 { lab=Vg}
N 1025 13095 1025 13170 { lab=Vg}
N 1185 13095 1185 13170 { lab=Vg}
N 700 13065 700 13095 { lab=VLX}
N 835 13065 835 13095 { lab=VLX}
N 985 13065 985 13095 { lab=VLX}
N 1145 13065 1145 13095 { lab=VLX}
N 1305 13065 1305 13095 { lab=VLX}
N 1440 13065 1575 13065 { lab=VLX}
N 1575 13065 1725 13065 { lab=VLX}
N 1725 13065 1885 13065 { lab=VLX}
N 1885 13065 2045 13065 { lab=VLX}
N 1440 13125 1575 13125 { lab=Vout}
N 1575 13125 1725 13125 { lab=Vout}
N 1725 13125 1885 13125 { lab=Vout}
N 1885 13125 2045 13125 { lab=Vout}
N 1480 13095 1480 13170 { lab=Vg}
N 1480 13170 1615 13170 { lab=Vg}
N 1615 13095 1615 13170 { lab=Vg}
N 1615 13170 1770 13170 { lab=Vg}
N 2085 13095 2085 13170 { lab=Vg}
N 1770 13170 2085 13170 { lab=Vg}
N 1765 13095 1765 13170 { lab=Vg}
N 1925 13095 1925 13170 { lab=Vg}
N 1440 13065 1440 13095 { lab=VLX}
N 1575 13065 1575 13095 { lab=VLX}
N 1725 13065 1725 13095 { lab=VLX}
N 1885 13065 1885 13095 { lab=VLX}
N 2045 13065 2045 13095 { lab=VLX}
N 1305 13065 1440 13065 { lab=VLX}
N 1305 13125 1440 13125 { lab=Vout}
N 1345 13170 1480 13170 { lab=Vg}
N 2195 13065 2330 13065 { lab=VLX}
N 2330 13065 2480 13065 { lab=VLX}
N 2480 13065 2640 13065 { lab=VLX}
N 2640 13065 2800 13065 { lab=VLX}
N 2195 13125 2330 13125 { lab=Vout}
N 2330 13125 2480 13125 { lab=Vout}
N 2480 13125 2640 13125 { lab=Vout}
N 2640 13125 2800 13125 { lab=Vout}
N 2235 13095 2235 13170 { lab=Vg}
N 2235 13170 2370 13170 { lab=Vg}
N 2370 13095 2370 13170 { lab=Vg}
N 2370 13170 2525 13170 { lab=Vg}
N 2840 13095 2840 13170 { lab=Vg}
N 2525 13170 2840 13170 { lab=Vg}
N 2520 13095 2520 13170 { lab=Vg}
N 2680 13095 2680 13170 { lab=Vg}
N 2195 13065 2195 13095 { lab=VLX}
N 2330 13065 2330 13095 { lab=VLX}
N 2480 13065 2480 13095 { lab=VLX}
N 2640 13065 2640 13095 { lab=VLX}
N 2800 13065 2800 13095 { lab=VLX}
N 2935 13065 3070 13065 { lab=VLX}
N 3070 13065 3220 13065 { lab=VLX}
N 3220 13065 3380 13065 { lab=VLX}
N 3380 13065 3540 13065 { lab=VLX}
N 2935 13125 3070 13125 { lab=Vout}
N 3070 13125 3220 13125 { lab=Vout}
N 3220 13125 3380 13125 { lab=Vout}
N 3380 13125 3540 13125 { lab=Vout}
N 2975 13095 2975 13170 { lab=Vg}
N 2975 13170 3110 13170 { lab=Vg}
N 3110 13095 3110 13170 { lab=Vg}
N 3110 13170 3265 13170 { lab=Vg}
N 3580 13095 3580 13170 { lab=Vg}
N 3265 13170 3580 13170 { lab=Vg}
N 3260 13095 3260 13170 { lab=Vg}
N 3420 13095 3420 13170 { lab=Vg}
N 2935 13065 2935 13095 { lab=VLX}
N 3070 13065 3070 13095 { lab=VLX}
N 3220 13065 3220 13095 { lab=VLX}
N 3380 13065 3380 13095 { lab=VLX}
N 3540 13065 3540 13095 { lab=VLX}
N 2800 13065 2935 13065 { lab=VLX}
N 2800 13125 2935 13125 { lab=Vout}
N 2840 13170 2975 13170 { lab=Vg}
N 2045 13065 2195 13065 { lab=VLX}
N 2085 13170 2235 13170 { lab=Vg}
N 2045 13125 2195 13125 { lab=Vout}
N 700 13230 835 13230 { lab=VLX}
N 835 13230 985 13230 { lab=VLX}
N 985 13230 1145 13230 { lab=VLX}
N 1145 13230 1305 13230 { lab=VLX}
N 700 13290 835 13290 { lab=Vout}
N 835 13290 985 13290 { lab=Vout}
N 985 13290 1145 13290 { lab=Vout}
N 1145 13290 1305 13290 { lab=Vout}
N 740 13260 740 13335 { lab=Vg}
N 740 13335 875 13335 { lab=Vg}
N 875 13260 875 13335 { lab=Vg}
N 875 13335 1030 13335 { lab=Vg}
N 1345 13260 1345 13335 { lab=Vg}
N 1030 13335 1345 13335 { lab=Vg}
N 1025 13260 1025 13335 { lab=Vg}
N 1185 13260 1185 13335 { lab=Vg}
N 700 13230 700 13260 { lab=VLX}
N 835 13230 835 13260 { lab=VLX}
N 985 13230 985 13260 { lab=VLX}
N 1145 13230 1145 13260 { lab=VLX}
N 1305 13230 1305 13260 { lab=VLX}
N 1440 13230 1575 13230 { lab=VLX}
N 1575 13230 1725 13230 { lab=VLX}
N 1725 13230 1885 13230 { lab=VLX}
N 1885 13230 2045 13230 { lab=VLX}
N 1440 13290 1575 13290 { lab=Vout}
N 1575 13290 1725 13290 { lab=Vout}
N 1725 13290 1885 13290 { lab=Vout}
N 1885 13290 2045 13290 { lab=Vout}
N 1480 13260 1480 13335 { lab=Vg}
N 1480 13335 1615 13335 { lab=Vg}
N 1615 13260 1615 13335 { lab=Vg}
N 1615 13335 1770 13335 { lab=Vg}
N 2085 13260 2085 13335 { lab=Vg}
N 1770 13335 2085 13335 { lab=Vg}
N 1765 13260 1765 13335 { lab=Vg}
N 1925 13260 1925 13335 { lab=Vg}
N 1440 13230 1440 13260 { lab=VLX}
N 1575 13230 1575 13260 { lab=VLX}
N 1725 13230 1725 13260 { lab=VLX}
N 1885 13230 1885 13260 { lab=VLX}
N 2045 13230 2045 13260 { lab=VLX}
N 1305 13230 1440 13230 { lab=VLX}
N 1305 13290 1440 13290 { lab=Vout}
N 1345 13335 1480 13335 { lab=Vg}
N 2195 13230 2330 13230 { lab=VLX}
N 2330 13230 2480 13230 { lab=VLX}
N 2480 13230 2640 13230 { lab=VLX}
N 2640 13230 2800 13230 { lab=VLX}
N 2195 13290 2330 13290 { lab=Vout}
N 2330 13290 2480 13290 { lab=Vout}
N 2480 13290 2640 13290 { lab=Vout}
N 2640 13290 2800 13290 { lab=Vout}
N 2235 13260 2235 13335 { lab=Vg}
N 2235 13335 2370 13335 { lab=Vg}
N 2370 13260 2370 13335 { lab=Vg}
N 2370 13335 2525 13335 { lab=Vg}
N 2840 13260 2840 13335 { lab=Vg}
N 2525 13335 2840 13335 { lab=Vg}
N 2520 13260 2520 13335 { lab=Vg}
N 2680 13260 2680 13335 { lab=Vg}
N 2195 13230 2195 13260 { lab=VLX}
N 2330 13230 2330 13260 { lab=VLX}
N 2480 13230 2480 13260 { lab=VLX}
N 2640 13230 2640 13260 { lab=VLX}
N 2800 13230 2800 13260 { lab=VLX}
N 2935 13230 3070 13230 { lab=VLX}
N 3070 13230 3220 13230 { lab=VLX}
N 3220 13230 3380 13230 { lab=VLX}
N 3380 13230 3540 13230 { lab=VLX}
N 2935 13290 3070 13290 { lab=Vout}
N 3070 13290 3220 13290 { lab=Vout}
N 3220 13290 3380 13290 { lab=Vout}
N 3380 13290 3540 13290 { lab=Vout}
N 2975 13260 2975 13335 { lab=Vg}
N 2975 13335 3110 13335 { lab=Vg}
N 3110 13260 3110 13335 { lab=Vg}
N 3110 13335 3265 13335 { lab=Vg}
N 3580 13260 3580 13335 { lab=Vg}
N 3265 13335 3580 13335 { lab=Vg}
N 3260 13260 3260 13335 { lab=Vg}
N 3420 13260 3420 13335 { lab=Vg}
N 2935 13230 2935 13260 { lab=VLX}
N 3070 13230 3070 13260 { lab=VLX}
N 3220 13230 3220 13260 { lab=VLX}
N 3380 13230 3380 13260 { lab=VLX}
N 3540 13230 3540 13260 { lab=VLX}
N 2800 13230 2935 13230 { lab=VLX}
N 2800 13290 2935 13290 { lab=Vout}
N 2840 13335 2975 13335 { lab=Vg}
N 2045 13230 2195 13230 { lab=VLX}
N 2085 13335 2235 13335 { lab=Vg}
N 2045 13290 2195 13290 { lab=Vout}
N 3580 13170 3580 13260 { lab=Vg}
N 455 13065 700 13065 { lab=VLX}
N 450 13230 700 13230 { lab=VLX}
N 450 13065 450 13230 { lab=VLX}
N 450 13065 455 13065 { lab=VLX}
N 570 13125 700 13125 { lab=Vout}
N 570 13125 570 13335 { lab=Vout}
N 450 12880 450 13070 { lab=VLX}
N 570 12980 570 13130 { lab=Vout}
N 3580 12980 3580 13100 { lab=Vg}
N 450 12560 450 12720 { lab=VLX}
N 570 12660 570 12780 { lab=Vout}
N 3580 12670 3580 12740 { lab=Vg}
N 3580 12660 3580 12670 { lab=Vg}
N 700 13465 835 13465 { lab=VLX}
N 835 13465 985 13465 { lab=VLX}
N 985 13465 1145 13465 { lab=VLX}
N 1145 13465 1305 13465 { lab=VLX}
N 700 13525 835 13525 { lab=Vout}
N 835 13525 985 13525 { lab=Vout}
N 985 13525 1145 13525 { lab=Vout}
N 1145 13525 1305 13525 { lab=Vout}
N 740 13495 740 13570 { lab=Vg}
N 740 13570 875 13570 { lab=Vg}
N 875 13495 875 13570 { lab=Vg}
N 875 13570 1030 13570 { lab=Vg}
N 1345 13495 1345 13570 { lab=Vg}
N 1030 13570 1345 13570 { lab=Vg}
N 1025 13495 1025 13570 { lab=Vg}
N 1185 13495 1185 13570 { lab=Vg}
N 700 13465 700 13495 { lab=VLX}
N 835 13465 835 13495 { lab=VLX}
N 985 13465 985 13495 { lab=VLX}
N 1145 13465 1145 13495 { lab=VLX}
N 1305 13465 1305 13495 { lab=VLX}
N 1440 13465 1575 13465 { lab=VLX}
N 1575 13465 1725 13465 { lab=VLX}
N 1725 13465 1885 13465 { lab=VLX}
N 1885 13465 2045 13465 { lab=VLX}
N 1440 13525 1575 13525 { lab=Vout}
N 1575 13525 1725 13525 { lab=Vout}
N 1725 13525 1885 13525 { lab=Vout}
N 1885 13525 2045 13525 { lab=Vout}
N 1480 13495 1480 13570 { lab=Vg}
N 1480 13570 1615 13570 { lab=Vg}
N 1615 13495 1615 13570 { lab=Vg}
N 1615 13570 1770 13570 { lab=Vg}
N 2085 13495 2085 13570 { lab=Vg}
N 1770 13570 2085 13570 { lab=Vg}
N 1765 13495 1765 13570 { lab=Vg}
N 1925 13495 1925 13570 { lab=Vg}
N 1440 13465 1440 13495 { lab=VLX}
N 1575 13465 1575 13495 { lab=VLX}
N 1725 13465 1725 13495 { lab=VLX}
N 1885 13465 1885 13495 { lab=VLX}
N 2045 13465 2045 13495 { lab=VLX}
N 1305 13465 1440 13465 { lab=VLX}
N 1305 13525 1440 13525 { lab=Vout}
N 1345 13570 1480 13570 { lab=Vg}
N 2195 13465 2330 13465 { lab=VLX}
N 2330 13465 2480 13465 { lab=VLX}
N 2480 13465 2640 13465 { lab=VLX}
N 2640 13465 2800 13465 { lab=VLX}
N 2195 13525 2330 13525 { lab=Vout}
N 2330 13525 2480 13525 { lab=Vout}
N 2480 13525 2640 13525 { lab=Vout}
N 2640 13525 2800 13525 { lab=Vout}
N 2235 13495 2235 13570 { lab=Vg}
N 2235 13570 2370 13570 { lab=Vg}
N 2370 13495 2370 13570 { lab=Vg}
N 2370 13570 2525 13570 { lab=Vg}
N 2840 13495 2840 13570 { lab=Vg}
N 2525 13570 2840 13570 { lab=Vg}
N 2520 13495 2520 13570 { lab=Vg}
N 2680 13495 2680 13570 { lab=Vg}
N 2195 13465 2195 13495 { lab=VLX}
N 2330 13465 2330 13495 { lab=VLX}
N 2480 13465 2480 13495 { lab=VLX}
N 2640 13465 2640 13495 { lab=VLX}
N 2800 13465 2800 13495 { lab=VLX}
N 2935 13465 3070 13465 { lab=VLX}
N 3070 13465 3220 13465 { lab=VLX}
N 3220 13465 3380 13465 { lab=VLX}
N 3380 13465 3540 13465 { lab=VLX}
N 2935 13525 3070 13525 { lab=Vout}
N 3070 13525 3220 13525 { lab=Vout}
N 3220 13525 3380 13525 { lab=Vout}
N 3380 13525 3540 13525 { lab=Vout}
N 2975 13495 2975 13570 { lab=Vg}
N 2975 13570 3110 13570 { lab=Vg}
N 3110 13495 3110 13570 { lab=Vg}
N 3110 13570 3265 13570 { lab=Vg}
N 3580 13495 3580 13570 { lab=Vg}
N 3265 13570 3580 13570 { lab=Vg}
N 3260 13495 3260 13570 { lab=Vg}
N 3420 13495 3420 13570 { lab=Vg}
N 2935 13465 2935 13495 { lab=VLX}
N 3070 13465 3070 13495 { lab=VLX}
N 3220 13465 3220 13495 { lab=VLX}
N 3380 13465 3380 13495 { lab=VLX}
N 3540 13465 3540 13495 { lab=VLX}
N 2800 13465 2935 13465 { lab=VLX}
N 2800 13525 2935 13525 { lab=Vout}
N 2840 13570 2975 13570 { lab=Vg}
N 2045 13465 2195 13465 { lab=VLX}
N 2085 13570 2235 13570 { lab=Vg}
N 2045 13525 2195 13525 { lab=Vout}
N 700 13630 835 13630 { lab=VLX}
N 835 13630 985 13630 { lab=VLX}
N 985 13630 1145 13630 { lab=VLX}
N 1145 13630 1305 13630 { lab=VLX}
N 700 13690 835 13690 { lab=Vout}
N 835 13690 985 13690 { lab=Vout}
N 985 13690 1145 13690 { lab=Vout}
N 1145 13690 1305 13690 { lab=Vout}
N 740 13660 740 13735 { lab=Vg}
N 740 13735 875 13735 { lab=Vg}
N 875 13660 875 13735 { lab=Vg}
N 875 13735 1030 13735 { lab=Vg}
N 1345 13660 1345 13735 { lab=Vg}
N 1030 13735 1345 13735 { lab=Vg}
N 1025 13660 1025 13735 { lab=Vg}
N 1185 13660 1185 13735 { lab=Vg}
N 700 13630 700 13660 { lab=VLX}
N 835 13630 835 13660 { lab=VLX}
N 985 13630 985 13660 { lab=VLX}
N 1145 13630 1145 13660 { lab=VLX}
N 1305 13630 1305 13660 { lab=VLX}
N 1440 13630 1575 13630 { lab=VLX}
N 1575 13630 1725 13630 { lab=VLX}
N 1725 13630 1885 13630 { lab=VLX}
N 1885 13630 2045 13630 { lab=VLX}
N 1440 13690 1575 13690 { lab=Vout}
N 1575 13690 1725 13690 { lab=Vout}
N 1725 13690 1885 13690 { lab=Vout}
N 1885 13690 2045 13690 { lab=Vout}
N 1480 13660 1480 13735 { lab=Vg}
N 1480 13735 1615 13735 { lab=Vg}
N 1615 13660 1615 13735 { lab=Vg}
N 1615 13735 1770 13735 { lab=Vg}
N 2085 13660 2085 13735 { lab=Vg}
N 1770 13735 2085 13735 { lab=Vg}
N 1765 13660 1765 13735 { lab=Vg}
N 1925 13660 1925 13735 { lab=Vg}
N 1440 13630 1440 13660 { lab=VLX}
N 1575 13630 1575 13660 { lab=VLX}
N 1725 13630 1725 13660 { lab=VLX}
N 1885 13630 1885 13660 { lab=VLX}
N 2045 13630 2045 13660 { lab=VLX}
N 1305 13630 1440 13630 { lab=VLX}
N 1305 13690 1440 13690 { lab=Vout}
N 1345 13735 1480 13735 { lab=Vg}
N 2195 13630 2330 13630 { lab=VLX}
N 2330 13630 2480 13630 { lab=VLX}
N 2480 13630 2640 13630 { lab=VLX}
N 2640 13630 2800 13630 { lab=VLX}
N 2195 13690 2330 13690 { lab=Vout}
N 2330 13690 2480 13690 { lab=Vout}
N 2480 13690 2640 13690 { lab=Vout}
N 2640 13690 2800 13690 { lab=Vout}
N 2235 13660 2235 13735 { lab=Vg}
N 2235 13735 2370 13735 { lab=Vg}
N 2370 13660 2370 13735 { lab=Vg}
N 2370 13735 2525 13735 { lab=Vg}
N 2840 13660 2840 13735 { lab=Vg}
N 2525 13735 2840 13735 { lab=Vg}
N 2520 13660 2520 13735 { lab=Vg}
N 2680 13660 2680 13735 { lab=Vg}
N 2195 13630 2195 13660 { lab=VLX}
N 2330 13630 2330 13660 { lab=VLX}
N 2480 13630 2480 13660 { lab=VLX}
N 2640 13630 2640 13660 { lab=VLX}
N 2800 13630 2800 13660 { lab=VLX}
N 2935 13630 3070 13630 { lab=VLX}
N 3070 13630 3220 13630 { lab=VLX}
N 3220 13630 3380 13630 { lab=VLX}
N 3380 13630 3540 13630 { lab=VLX}
N 2935 13690 3070 13690 { lab=Vout}
N 3070 13690 3220 13690 { lab=Vout}
N 3220 13690 3380 13690 { lab=Vout}
N 3380 13690 3540 13690 { lab=Vout}
N 2975 13660 2975 13735 { lab=Vg}
N 2975 13735 3110 13735 { lab=Vg}
N 3110 13660 3110 13735 { lab=Vg}
N 3110 13735 3265 13735 { lab=Vg}
N 3580 13660 3580 13735 { lab=Vg}
N 3265 13735 3580 13735 { lab=Vg}
N 3260 13660 3260 13735 { lab=Vg}
N 3420 13660 3420 13735 { lab=Vg}
N 2935 13630 2935 13660 { lab=VLX}
N 3070 13630 3070 13660 { lab=VLX}
N 3220 13630 3220 13660 { lab=VLX}
N 3380 13630 3380 13660 { lab=VLX}
N 3540 13630 3540 13660 { lab=VLX}
N 2800 13630 2935 13630 { lab=VLX}
N 2800 13690 2935 13690 { lab=Vout}
N 2840 13735 2975 13735 { lab=Vg}
N 2045 13630 2195 13630 { lab=VLX}
N 2085 13735 2235 13735 { lab=Vg}
N 2045 13690 2195 13690 { lab=Vout}
N 3580 13570 3580 13660 { lab=Vg}
N 455 13465 700 13465 { lab=VLX}
N 450 13630 700 13630 { lab=VLX}
N 450 13465 450 13630 { lab=VLX}
N 450 13465 455 13465 { lab=VLX}
N 570 13525 700 13525 { lab=Vout}
N 570 13525 570 13735 { lab=Vout}
N 700 13815 835 13815 { lab=VLX}
N 835 13815 985 13815 { lab=VLX}
N 985 13815 1145 13815 { lab=VLX}
N 1145 13815 1305 13815 { lab=VLX}
N 700 13875 835 13875 { lab=Vout}
N 835 13875 985 13875 { lab=Vout}
N 985 13875 1145 13875 { lab=Vout}
N 1145 13875 1305 13875 { lab=Vout}
N 740 13845 740 13920 { lab=Vg}
N 740 13920 875 13920 { lab=Vg}
N 875 13845 875 13920 { lab=Vg}
N 875 13920 1030 13920 { lab=Vg}
N 1345 13845 1345 13920 { lab=Vg}
N 1030 13920 1345 13920 { lab=Vg}
N 1025 13845 1025 13920 { lab=Vg}
N 1185 13845 1185 13920 { lab=Vg}
N 700 13815 700 13845 { lab=VLX}
N 835 13815 835 13845 { lab=VLX}
N 985 13815 985 13845 { lab=VLX}
N 1145 13815 1145 13845 { lab=VLX}
N 1305 13815 1305 13845 { lab=VLX}
N 1440 13815 1575 13815 { lab=VLX}
N 1575 13815 1725 13815 { lab=VLX}
N 1725 13815 1885 13815 { lab=VLX}
N 1885 13815 2045 13815 { lab=VLX}
N 1440 13875 1575 13875 { lab=Vout}
N 1575 13875 1725 13875 { lab=Vout}
N 1725 13875 1885 13875 { lab=Vout}
N 1885 13875 2045 13875 { lab=Vout}
N 1480 13845 1480 13920 { lab=Vg}
N 1480 13920 1615 13920 { lab=Vg}
N 1615 13845 1615 13920 { lab=Vg}
N 1615 13920 1770 13920 { lab=Vg}
N 2085 13845 2085 13920 { lab=Vg}
N 1770 13920 2085 13920 { lab=Vg}
N 1765 13845 1765 13920 { lab=Vg}
N 1925 13845 1925 13920 { lab=Vg}
N 1440 13815 1440 13845 { lab=VLX}
N 1575 13815 1575 13845 { lab=VLX}
N 1725 13815 1725 13845 { lab=VLX}
N 1885 13815 1885 13845 { lab=VLX}
N 2045 13815 2045 13845 { lab=VLX}
N 1305 13815 1440 13815 { lab=VLX}
N 1305 13875 1440 13875 { lab=Vout}
N 1345 13920 1480 13920 { lab=Vg}
N 2195 13815 2330 13815 { lab=VLX}
N 2330 13815 2480 13815 { lab=VLX}
N 2480 13815 2640 13815 { lab=VLX}
N 2640 13815 2800 13815 { lab=VLX}
N 2195 13875 2330 13875 { lab=Vout}
N 2330 13875 2480 13875 { lab=Vout}
N 2480 13875 2640 13875 { lab=Vout}
N 2640 13875 2800 13875 { lab=Vout}
N 2235 13845 2235 13920 { lab=Vg}
N 2235 13920 2370 13920 { lab=Vg}
N 2370 13845 2370 13920 { lab=Vg}
N 2370 13920 2525 13920 { lab=Vg}
N 2840 13845 2840 13920 { lab=Vg}
N 2525 13920 2840 13920 { lab=Vg}
N 2520 13845 2520 13920 { lab=Vg}
N 2680 13845 2680 13920 { lab=Vg}
N 2195 13815 2195 13845 { lab=VLX}
N 2330 13815 2330 13845 { lab=VLX}
N 2480 13815 2480 13845 { lab=VLX}
N 2640 13815 2640 13845 { lab=VLX}
N 2800 13815 2800 13845 { lab=VLX}
N 2935 13815 3070 13815 { lab=VLX}
N 3070 13815 3220 13815 { lab=VLX}
N 3220 13815 3380 13815 { lab=VLX}
N 3380 13815 3540 13815 { lab=VLX}
N 2935 13875 3070 13875 { lab=Vout}
N 3070 13875 3220 13875 { lab=Vout}
N 3220 13875 3380 13875 { lab=Vout}
N 3380 13875 3540 13875 { lab=Vout}
N 2975 13845 2975 13920 { lab=Vg}
N 2975 13920 3110 13920 { lab=Vg}
N 3110 13845 3110 13920 { lab=Vg}
N 3110 13920 3265 13920 { lab=Vg}
N 3580 13845 3580 13920 { lab=Vg}
N 3265 13920 3580 13920 { lab=Vg}
N 3260 13845 3260 13920 { lab=Vg}
N 3420 13845 3420 13920 { lab=Vg}
N 2935 13815 2935 13845 { lab=VLX}
N 3070 13815 3070 13845 { lab=VLX}
N 3220 13815 3220 13845 { lab=VLX}
N 3380 13815 3380 13845 { lab=VLX}
N 3540 13815 3540 13845 { lab=VLX}
N 2800 13815 2935 13815 { lab=VLX}
N 2800 13875 2935 13875 { lab=Vout}
N 2840 13920 2975 13920 { lab=Vg}
N 2045 13815 2195 13815 { lab=VLX}
N 2085 13920 2235 13920 { lab=Vg}
N 2045 13875 2195 13875 { lab=Vout}
N 700 13980 835 13980 { lab=VLX}
N 835 13980 985 13980 { lab=VLX}
N 985 13980 1145 13980 { lab=VLX}
N 1145 13980 1305 13980 { lab=VLX}
N 700 14040 835 14040 { lab=Vout}
N 835 14040 985 14040 { lab=Vout}
N 985 14040 1145 14040 { lab=Vout}
N 1145 14040 1305 14040 { lab=Vout}
N 740 14010 740 14085 { lab=Vg}
N 740 14085 875 14085 { lab=Vg}
N 875 14010 875 14085 { lab=Vg}
N 875 14085 1030 14085 { lab=Vg}
N 1345 14010 1345 14085 { lab=Vg}
N 1030 14085 1345 14085 { lab=Vg}
N 1025 14010 1025 14085 { lab=Vg}
N 1185 14010 1185 14085 { lab=Vg}
N 700 13980 700 14010 { lab=VLX}
N 835 13980 835 14010 { lab=VLX}
N 985 13980 985 14010 { lab=VLX}
N 1145 13980 1145 14010 { lab=VLX}
N 1305 13980 1305 14010 { lab=VLX}
N 1440 13980 1575 13980 { lab=VLX}
N 1575 13980 1725 13980 { lab=VLX}
N 1725 13980 1885 13980 { lab=VLX}
N 1885 13980 2045 13980 { lab=VLX}
N 1440 14040 1575 14040 { lab=Vout}
N 1575 14040 1725 14040 { lab=Vout}
N 1725 14040 1885 14040 { lab=Vout}
N 1885 14040 2045 14040 { lab=Vout}
N 1480 14010 1480 14085 { lab=Vg}
N 1480 14085 1615 14085 { lab=Vg}
N 1615 14010 1615 14085 { lab=Vg}
N 1615 14085 1770 14085 { lab=Vg}
N 2085 14010 2085 14085 { lab=Vg}
N 1770 14085 2085 14085 { lab=Vg}
N 1765 14010 1765 14085 { lab=Vg}
N 1925 14010 1925 14085 { lab=Vg}
N 1440 13980 1440 14010 { lab=VLX}
N 1575 13980 1575 14010 { lab=VLX}
N 1725 13980 1725 14010 { lab=VLX}
N 1885 13980 1885 14010 { lab=VLX}
N 2045 13980 2045 14010 { lab=VLX}
N 1305 13980 1440 13980 { lab=VLX}
N 1305 14040 1440 14040 { lab=Vout}
N 1345 14085 1480 14085 { lab=Vg}
N 2195 13980 2330 13980 { lab=VLX}
N 2330 13980 2480 13980 { lab=VLX}
N 2480 13980 2640 13980 { lab=VLX}
N 2640 13980 2800 13980 { lab=VLX}
N 2195 14040 2330 14040 { lab=Vout}
N 2330 14040 2480 14040 { lab=Vout}
N 2480 14040 2640 14040 { lab=Vout}
N 2640 14040 2800 14040 { lab=Vout}
N 2235 14010 2235 14085 { lab=Vg}
N 2235 14085 2370 14085 { lab=Vg}
N 2370 14010 2370 14085 { lab=Vg}
N 2370 14085 2525 14085 { lab=Vg}
N 2840 14010 2840 14085 { lab=Vg}
N 2525 14085 2840 14085 { lab=Vg}
N 2520 14010 2520 14085 { lab=Vg}
N 2680 14010 2680 14085 { lab=Vg}
N 2195 13980 2195 14010 { lab=VLX}
N 2330 13980 2330 14010 { lab=VLX}
N 2480 13980 2480 14010 { lab=VLX}
N 2640 13980 2640 14010 { lab=VLX}
N 2800 13980 2800 14010 { lab=VLX}
N 2935 13980 3070 13980 { lab=VLX}
N 3070 13980 3220 13980 { lab=VLX}
N 3220 13980 3380 13980 { lab=VLX}
N 3380 13980 3540 13980 { lab=VLX}
N 2935 14040 3070 14040 { lab=Vout}
N 3070 14040 3220 14040 { lab=Vout}
N 3220 14040 3380 14040 { lab=Vout}
N 3380 14040 3540 14040 { lab=Vout}
N 2975 14010 2975 14085 { lab=Vg}
N 2975 14085 3110 14085 { lab=Vg}
N 3110 14010 3110 14085 { lab=Vg}
N 3110 14085 3265 14085 { lab=Vg}
N 3580 14010 3580 14085 { lab=Vg}
N 3265 14085 3580 14085 { lab=Vg}
N 3260 14010 3260 14085 { lab=Vg}
N 3420 14010 3420 14085 { lab=Vg}
N 2935 13980 2935 14010 { lab=VLX}
N 3070 13980 3070 14010 { lab=VLX}
N 3220 13980 3220 14010 { lab=VLX}
N 3380 13980 3380 14010 { lab=VLX}
N 3540 13980 3540 14010 { lab=VLX}
N 2800 13980 2935 13980 { lab=VLX}
N 2800 14040 2935 14040 { lab=Vout}
N 2840 14085 2975 14085 { lab=Vg}
N 2045 13980 2195 13980 { lab=VLX}
N 2085 14085 2235 14085 { lab=Vg}
N 2045 14040 2195 14040 { lab=Vout}
N 3580 13920 3580 14010 { lab=Vg}
N 455 13815 700 13815 { lab=VLX}
N 450 13980 700 13980 { lab=VLX}
N 450 13815 450 13980 { lab=VLX}
N 450 13815 455 13815 { lab=VLX}
N 570 13875 700 13875 { lab=Vout}
N 570 13875 570 14085 { lab=Vout}
N 450 13630 450 13820 { lab=VLX}
N 570 13730 570 13880 { lab=Vout}
N 3580 13730 3580 13850 { lab=Vg}
N 700 14135 835 14135 { lab=VLX}
N 835 14135 985 14135 { lab=VLX}
N 985 14135 1145 14135 { lab=VLX}
N 1145 14135 1305 14135 { lab=VLX}
N 700 14195 835 14195 { lab=Vout}
N 835 14195 985 14195 { lab=Vout}
N 985 14195 1145 14195 { lab=Vout}
N 1145 14195 1305 14195 { lab=Vout}
N 740 14165 740 14240 { lab=Vg}
N 740 14240 875 14240 { lab=Vg}
N 875 14165 875 14240 { lab=Vg}
N 875 14240 1030 14240 { lab=Vg}
N 1345 14165 1345 14240 { lab=Vg}
N 1030 14240 1345 14240 { lab=Vg}
N 1025 14165 1025 14240 { lab=Vg}
N 1185 14165 1185 14240 { lab=Vg}
N 700 14135 700 14165 { lab=VLX}
N 835 14135 835 14165 { lab=VLX}
N 985 14135 985 14165 { lab=VLX}
N 1145 14135 1145 14165 { lab=VLX}
N 1305 14135 1305 14165 { lab=VLX}
N 1440 14135 1575 14135 { lab=VLX}
N 1575 14135 1725 14135 { lab=VLX}
N 1725 14135 1885 14135 { lab=VLX}
N 1885 14135 2045 14135 { lab=VLX}
N 1440 14195 1575 14195 { lab=Vout}
N 1575 14195 1725 14195 { lab=Vout}
N 1725 14195 1885 14195 { lab=Vout}
N 1885 14195 2045 14195 { lab=Vout}
N 1480 14165 1480 14240 { lab=Vg}
N 1480 14240 1615 14240 { lab=Vg}
N 1615 14165 1615 14240 { lab=Vg}
N 1615 14240 1770 14240 { lab=Vg}
N 2085 14165 2085 14240 { lab=Vg}
N 1770 14240 2085 14240 { lab=Vg}
N 1765 14165 1765 14240 { lab=Vg}
N 1925 14165 1925 14240 { lab=Vg}
N 1440 14135 1440 14165 { lab=VLX}
N 1575 14135 1575 14165 { lab=VLX}
N 1725 14135 1725 14165 { lab=VLX}
N 1885 14135 1885 14165 { lab=VLX}
N 2045 14135 2045 14165 { lab=VLX}
N 1305 14135 1440 14135 { lab=VLX}
N 1305 14195 1440 14195 { lab=Vout}
N 1345 14240 1480 14240 { lab=Vg}
N 2195 14135 2330 14135 { lab=VLX}
N 2330 14135 2480 14135 { lab=VLX}
N 2480 14135 2640 14135 { lab=VLX}
N 2640 14135 2800 14135 { lab=VLX}
N 2195 14195 2330 14195 { lab=Vout}
N 2330 14195 2480 14195 { lab=Vout}
N 2480 14195 2640 14195 { lab=Vout}
N 2640 14195 2800 14195 { lab=Vout}
N 2235 14165 2235 14240 { lab=Vg}
N 2235 14240 2370 14240 { lab=Vg}
N 2370 14165 2370 14240 { lab=Vg}
N 2370 14240 2525 14240 { lab=Vg}
N 2840 14165 2840 14240 { lab=Vg}
N 2525 14240 2840 14240 { lab=Vg}
N 2520 14165 2520 14240 { lab=Vg}
N 2680 14165 2680 14240 { lab=Vg}
N 2195 14135 2195 14165 { lab=VLX}
N 2330 14135 2330 14165 { lab=VLX}
N 2480 14135 2480 14165 { lab=VLX}
N 2640 14135 2640 14165 { lab=VLX}
N 2800 14135 2800 14165 { lab=VLX}
N 2935 14135 3070 14135 { lab=VLX}
N 3070 14135 3220 14135 { lab=VLX}
N 3220 14135 3380 14135 { lab=VLX}
N 3380 14135 3540 14135 { lab=VLX}
N 2935 14195 3070 14195 { lab=Vout}
N 3070 14195 3220 14195 { lab=Vout}
N 3220 14195 3380 14195 { lab=Vout}
N 3380 14195 3540 14195 { lab=Vout}
N 2975 14165 2975 14240 { lab=Vg}
N 2975 14240 3110 14240 { lab=Vg}
N 3110 14165 3110 14240 { lab=Vg}
N 3110 14240 3265 14240 { lab=Vg}
N 3580 14165 3580 14240 { lab=Vg}
N 3265 14240 3580 14240 { lab=Vg}
N 3260 14165 3260 14240 { lab=Vg}
N 3420 14165 3420 14240 { lab=Vg}
N 2935 14135 2935 14165 { lab=VLX}
N 3070 14135 3070 14165 { lab=VLX}
N 3220 14135 3220 14165 { lab=VLX}
N 3380 14135 3380 14165 { lab=VLX}
N 3540 14135 3540 14165 { lab=VLX}
N 2800 14135 2935 14135 { lab=VLX}
N 2800 14195 2935 14195 { lab=Vout}
N 2840 14240 2975 14240 { lab=Vg}
N 2045 14135 2195 14135 { lab=VLX}
N 2085 14240 2235 14240 { lab=Vg}
N 2045 14195 2195 14195 { lab=Vout}
N 700 14300 835 14300 { lab=VLX}
N 835 14300 985 14300 { lab=VLX}
N 985 14300 1145 14300 { lab=VLX}
N 1145 14300 1305 14300 { lab=VLX}
N 700 14360 835 14360 { lab=Vout}
N 835 14360 985 14360 { lab=Vout}
N 985 14360 1145 14360 { lab=Vout}
N 1145 14360 1305 14360 { lab=Vout}
N 740 14330 740 14405 { lab=Vg}
N 740 14405 875 14405 { lab=Vg}
N 875 14330 875 14405 { lab=Vg}
N 875 14405 1030 14405 { lab=Vg}
N 1345 14330 1345 14405 { lab=Vg}
N 1030 14405 1345 14405 { lab=Vg}
N 1025 14330 1025 14405 { lab=Vg}
N 1185 14330 1185 14405 { lab=Vg}
N 700 14300 700 14330 { lab=VLX}
N 835 14300 835 14330 { lab=VLX}
N 985 14300 985 14330 { lab=VLX}
N 1145 14300 1145 14330 { lab=VLX}
N 1305 14300 1305 14330 { lab=VLX}
N 1440 14300 1575 14300 { lab=VLX}
N 1575 14300 1725 14300 { lab=VLX}
N 1725 14300 1885 14300 { lab=VLX}
N 1885 14300 2045 14300 { lab=VLX}
N 1440 14360 1575 14360 { lab=Vout}
N 1575 14360 1725 14360 { lab=Vout}
N 1725 14360 1885 14360 { lab=Vout}
N 1885 14360 2045 14360 { lab=Vout}
N 1480 14330 1480 14405 { lab=Vg}
N 1480 14405 1615 14405 { lab=Vg}
N 1615 14330 1615 14405 { lab=Vg}
N 1615 14405 1770 14405 { lab=Vg}
N 2085 14330 2085 14405 { lab=Vg}
N 1770 14405 2085 14405 { lab=Vg}
N 1765 14330 1765 14405 { lab=Vg}
N 1925 14330 1925 14405 { lab=Vg}
N 1440 14300 1440 14330 { lab=VLX}
N 1575 14300 1575 14330 { lab=VLX}
N 1725 14300 1725 14330 { lab=VLX}
N 1885 14300 1885 14330 { lab=VLX}
N 2045 14300 2045 14330 { lab=VLX}
N 1305 14300 1440 14300 { lab=VLX}
N 1305 14360 1440 14360 { lab=Vout}
N 1345 14405 1480 14405 { lab=Vg}
N 2195 14300 2330 14300 { lab=VLX}
N 2330 14300 2480 14300 { lab=VLX}
N 2480 14300 2640 14300 { lab=VLX}
N 2640 14300 2800 14300 { lab=VLX}
N 2195 14360 2330 14360 { lab=Vout}
N 2330 14360 2480 14360 { lab=Vout}
N 2480 14360 2640 14360 { lab=Vout}
N 2640 14360 2800 14360 { lab=Vout}
N 2235 14330 2235 14405 { lab=Vg}
N 2235 14405 2370 14405 { lab=Vg}
N 2370 14330 2370 14405 { lab=Vg}
N 2370 14405 2525 14405 { lab=Vg}
N 2840 14330 2840 14405 { lab=Vg}
N 2525 14405 2840 14405 { lab=Vg}
N 2520 14330 2520 14405 { lab=Vg}
N 2680 14330 2680 14405 { lab=Vg}
N 2195 14300 2195 14330 { lab=VLX}
N 2330 14300 2330 14330 { lab=VLX}
N 2480 14300 2480 14330 { lab=VLX}
N 2640 14300 2640 14330 { lab=VLX}
N 2800 14300 2800 14330 { lab=VLX}
N 2935 14300 3070 14300 { lab=VLX}
N 3070 14300 3220 14300 { lab=VLX}
N 3220 14300 3380 14300 { lab=VLX}
N 3380 14300 3540 14300 { lab=VLX}
N 2935 14360 3070 14360 { lab=Vout}
N 3070 14360 3220 14360 { lab=Vout}
N 3220 14360 3380 14360 { lab=Vout}
N 3380 14360 3540 14360 { lab=Vout}
N 2975 14330 2975 14405 { lab=Vg}
N 2975 14405 3110 14405 { lab=Vg}
N 3110 14330 3110 14405 { lab=Vg}
N 3110 14405 3265 14405 { lab=Vg}
N 3580 14330 3580 14405 { lab=Vg}
N 3265 14405 3580 14405 { lab=Vg}
N 3260 14330 3260 14405 { lab=Vg}
N 3420 14330 3420 14405 { lab=Vg}
N 2935 14300 2935 14330 { lab=VLX}
N 3070 14300 3070 14330 { lab=VLX}
N 3220 14300 3220 14330 { lab=VLX}
N 3380 14300 3380 14330 { lab=VLX}
N 3540 14300 3540 14330 { lab=VLX}
N 2800 14300 2935 14300 { lab=VLX}
N 2800 14360 2935 14360 { lab=Vout}
N 2840 14405 2975 14405 { lab=Vg}
N 2045 14300 2195 14300 { lab=VLX}
N 2085 14405 2235 14405 { lab=Vg}
N 2045 14360 2195 14360 { lab=Vout}
N 3580 14240 3580 14330 { lab=Vg}
N 455 14135 700 14135 { lab=VLX}
N 450 14300 700 14300 { lab=VLX}
N 450 14135 450 14300 { lab=VLX}
N 450 14135 455 14135 { lab=VLX}
N 570 14195 700 14195 { lab=Vout}
N 570 14195 570 14405 { lab=Vout}
N 700 14485 835 14485 { lab=VLX}
N 835 14485 985 14485 { lab=VLX}
N 985 14485 1145 14485 { lab=VLX}
N 1145 14485 1305 14485 { lab=VLX}
N 700 14545 835 14545 { lab=Vout}
N 835 14545 985 14545 { lab=Vout}
N 985 14545 1145 14545 { lab=Vout}
N 1145 14545 1305 14545 { lab=Vout}
N 740 14515 740 14590 { lab=Vg}
N 740 14590 875 14590 { lab=Vg}
N 875 14515 875 14590 { lab=Vg}
N 875 14590 1030 14590 { lab=Vg}
N 1345 14515 1345 14590 { lab=Vg}
N 1030 14590 1345 14590 { lab=Vg}
N 1025 14515 1025 14590 { lab=Vg}
N 1185 14515 1185 14590 { lab=Vg}
N 700 14485 700 14515 { lab=VLX}
N 835 14485 835 14515 { lab=VLX}
N 985 14485 985 14515 { lab=VLX}
N 1145 14485 1145 14515 { lab=VLX}
N 1305 14485 1305 14515 { lab=VLX}
N 1440 14485 1575 14485 { lab=VLX}
N 1575 14485 1725 14485 { lab=VLX}
N 1725 14485 1885 14485 { lab=VLX}
N 1885 14485 2045 14485 { lab=VLX}
N 1440 14545 1575 14545 { lab=Vout}
N 1575 14545 1725 14545 { lab=Vout}
N 1725 14545 1885 14545 { lab=Vout}
N 1885 14545 2045 14545 { lab=Vout}
N 1480 14515 1480 14590 { lab=Vg}
N 1480 14590 1615 14590 { lab=Vg}
N 1615 14515 1615 14590 { lab=Vg}
N 1615 14590 1770 14590 { lab=Vg}
N 2085 14515 2085 14590 { lab=Vg}
N 1770 14590 2085 14590 { lab=Vg}
N 1765 14515 1765 14590 { lab=Vg}
N 1925 14515 1925 14590 { lab=Vg}
N 1440 14485 1440 14515 { lab=VLX}
N 1575 14485 1575 14515 { lab=VLX}
N 1725 14485 1725 14515 { lab=VLX}
N 1885 14485 1885 14515 { lab=VLX}
N 2045 14485 2045 14515 { lab=VLX}
N 1305 14485 1440 14485 { lab=VLX}
N 1305 14545 1440 14545 { lab=Vout}
N 1345 14590 1480 14590 { lab=Vg}
N 2195 14485 2330 14485 { lab=VLX}
N 2330 14485 2480 14485 { lab=VLX}
N 2480 14485 2640 14485 { lab=VLX}
N 2640 14485 2800 14485 { lab=VLX}
N 2195 14545 2330 14545 { lab=Vout}
N 2330 14545 2480 14545 { lab=Vout}
N 2480 14545 2640 14545 { lab=Vout}
N 2640 14545 2800 14545 { lab=Vout}
N 2235 14515 2235 14590 { lab=Vg}
N 2235 14590 2370 14590 { lab=Vg}
N 2370 14515 2370 14590 { lab=Vg}
N 2370 14590 2525 14590 { lab=Vg}
N 2840 14515 2840 14590 { lab=Vg}
N 2525 14590 2840 14590 { lab=Vg}
N 2520 14515 2520 14590 { lab=Vg}
N 2680 14515 2680 14590 { lab=Vg}
N 2195 14485 2195 14515 { lab=VLX}
N 2330 14485 2330 14515 { lab=VLX}
N 2480 14485 2480 14515 { lab=VLX}
N 2640 14485 2640 14515 { lab=VLX}
N 2800 14485 2800 14515 { lab=VLX}
N 2935 14485 3070 14485 { lab=VLX}
N 3070 14485 3220 14485 { lab=VLX}
N 3220 14485 3380 14485 { lab=VLX}
N 3380 14485 3540 14485 { lab=VLX}
N 2935 14545 3070 14545 { lab=Vout}
N 3070 14545 3220 14545 { lab=Vout}
N 3220 14545 3380 14545 { lab=Vout}
N 3380 14545 3540 14545 { lab=Vout}
N 2975 14515 2975 14590 { lab=Vg}
N 2975 14590 3110 14590 { lab=Vg}
N 3110 14515 3110 14590 { lab=Vg}
N 3110 14590 3265 14590 { lab=Vg}
N 3580 14515 3580 14590 { lab=Vg}
N 3265 14590 3580 14590 { lab=Vg}
N 3260 14515 3260 14590 { lab=Vg}
N 3420 14515 3420 14590 { lab=Vg}
N 2935 14485 2935 14515 { lab=VLX}
N 3070 14485 3070 14515 { lab=VLX}
N 3220 14485 3220 14515 { lab=VLX}
N 3380 14485 3380 14515 { lab=VLX}
N 3540 14485 3540 14515 { lab=VLX}
N 2800 14485 2935 14485 { lab=VLX}
N 2800 14545 2935 14545 { lab=Vout}
N 2840 14590 2975 14590 { lab=Vg}
N 2045 14485 2195 14485 { lab=VLX}
N 2085 14590 2235 14590 { lab=Vg}
N 2045 14545 2195 14545 { lab=Vout}
N 700 14650 835 14650 { lab=VLX}
N 835 14650 985 14650 { lab=VLX}
N 985 14650 1145 14650 { lab=VLX}
N 1145 14650 1305 14650 { lab=VLX}
N 700 14710 835 14710 { lab=Vout}
N 835 14710 985 14710 { lab=Vout}
N 985 14710 1145 14710 { lab=Vout}
N 1145 14710 1305 14710 { lab=Vout}
N 740 14680 740 14755 { lab=Vg}
N 740 14755 875 14755 { lab=Vg}
N 875 14680 875 14755 { lab=Vg}
N 875 14755 1030 14755 { lab=Vg}
N 1345 14680 1345 14755 { lab=Vg}
N 1030 14755 1345 14755 { lab=Vg}
N 1025 14680 1025 14755 { lab=Vg}
N 1185 14680 1185 14755 { lab=Vg}
N 700 14650 700 14680 { lab=VLX}
N 835 14650 835 14680 { lab=VLX}
N 985 14650 985 14680 { lab=VLX}
N 1145 14650 1145 14680 { lab=VLX}
N 1305 14650 1305 14680 { lab=VLX}
N 1440 14650 1575 14650 { lab=VLX}
N 1575 14650 1725 14650 { lab=VLX}
N 1725 14650 1885 14650 { lab=VLX}
N 1885 14650 2045 14650 { lab=VLX}
N 1440 14710 1575 14710 { lab=Vout}
N 1575 14710 1725 14710 { lab=Vout}
N 1725 14710 1885 14710 { lab=Vout}
N 1885 14710 2045 14710 { lab=Vout}
N 1480 14680 1480 14755 { lab=Vg}
N 1480 14755 1615 14755 { lab=Vg}
N 1615 14680 1615 14755 { lab=Vg}
N 1615 14755 1770 14755 { lab=Vg}
N 2085 14680 2085 14755 { lab=Vg}
N 1770 14755 2085 14755 { lab=Vg}
N 1765 14680 1765 14755 { lab=Vg}
N 1925 14680 1925 14755 { lab=Vg}
N 1440 14650 1440 14680 { lab=VLX}
N 1575 14650 1575 14680 { lab=VLX}
N 1725 14650 1725 14680 { lab=VLX}
N 1885 14650 1885 14680 { lab=VLX}
N 2045 14650 2045 14680 { lab=VLX}
N 1305 14650 1440 14650 { lab=VLX}
N 1305 14710 1440 14710 { lab=Vout}
N 1345 14755 1480 14755 { lab=Vg}
N 2195 14650 2330 14650 { lab=VLX}
N 2330 14650 2480 14650 { lab=VLX}
N 2480 14650 2640 14650 { lab=VLX}
N 2640 14650 2800 14650 { lab=VLX}
N 2195 14710 2330 14710 { lab=Vout}
N 2330 14710 2480 14710 { lab=Vout}
N 2480 14710 2640 14710 { lab=Vout}
N 2640 14710 2800 14710 { lab=Vout}
N 2235 14680 2235 14755 { lab=Vg}
N 2235 14755 2370 14755 { lab=Vg}
N 2370 14680 2370 14755 { lab=Vg}
N 2370 14755 2525 14755 { lab=Vg}
N 2840 14680 2840 14755 { lab=Vg}
N 2525 14755 2840 14755 { lab=Vg}
N 2520 14680 2520 14755 { lab=Vg}
N 2680 14680 2680 14755 { lab=Vg}
N 2195 14650 2195 14680 { lab=VLX}
N 2330 14650 2330 14680 { lab=VLX}
N 2480 14650 2480 14680 { lab=VLX}
N 2640 14650 2640 14680 { lab=VLX}
N 2800 14650 2800 14680 { lab=VLX}
N 2935 14650 3070 14650 { lab=VLX}
N 3070 14650 3220 14650 { lab=VLX}
N 3220 14650 3380 14650 { lab=VLX}
N 3380 14650 3540 14650 { lab=VLX}
N 2935 14710 3070 14710 { lab=Vout}
N 3070 14710 3220 14710 { lab=Vout}
N 3220 14710 3380 14710 { lab=Vout}
N 3380 14710 3540 14710 { lab=Vout}
N 2975 14680 2975 14755 { lab=Vg}
N 2975 14755 3110 14755 { lab=Vg}
N 3110 14680 3110 14755 { lab=Vg}
N 3110 14755 3265 14755 { lab=Vg}
N 3580 14680 3580 14755 { lab=Vg}
N 3265 14755 3580 14755 { lab=Vg}
N 3260 14680 3260 14755 { lab=Vg}
N 3420 14680 3420 14755 { lab=Vg}
N 2935 14650 2935 14680 { lab=VLX}
N 3070 14650 3070 14680 { lab=VLX}
N 3220 14650 3220 14680 { lab=VLX}
N 3380 14650 3380 14680 { lab=VLX}
N 3540 14650 3540 14680 { lab=VLX}
N 2800 14650 2935 14650 { lab=VLX}
N 2800 14710 2935 14710 { lab=Vout}
N 2840 14755 2975 14755 { lab=Vg}
N 2045 14650 2195 14650 { lab=VLX}
N 2085 14755 2235 14755 { lab=Vg}
N 2045 14710 2195 14710 { lab=Vout}
N 3580 14590 3580 14680 { lab=Vg}
N 455 14485 700 14485 { lab=VLX}
N 450 14650 700 14650 { lab=VLX}
N 450 14485 450 14650 { lab=VLX}
N 450 14485 455 14485 { lab=VLX}
N 570 14545 700 14545 { lab=Vout}
N 570 14545 570 14755 { lab=Vout}
N 450 14300 450 14490 { lab=VLX}
N 570 14400 570 14550 { lab=Vout}
N 3580 14400 3580 14520 { lab=Vg}
N 450 13980 450 14140 { lab=VLX}
N 570 14080 570 14200 { lab=Vout}
N 3580 14090 3580 14160 { lab=Vg}
N 3580 14080 3580 14090 { lab=Vg}
N 3580 13330 3580 13500 { lab=Vg}
N 570 13330 570 13540 { lab=Vout}
N 450 13230 450 13470 { lab=VLX}
N 3580 11890 3580 12080 { lab=Vg}
N 570 11880 570 12110 { lab=Vout}
N 450 11790 450 12050 { lab=VLX}
N 500 3100 520 3410 { lab=Vout}
N 520 3410 520 3420 { lab=Vout}
N 380 3000 400 3360 { lab=VLX}
N 3510 3100 3530 3390 { lab=Vg}
N 3530 8930 3580 9220 { lab=Vg}
N 520 8920 570 9250 { lab=Vout}
N 400 8820 450 9190 { lab=VLX}
N 700 14875 835 14875 { lab=VLX}
N 835 14875 985 14875 { lab=VLX}
N 985 14875 1145 14875 { lab=VLX}
N 1145 14875 1305 14875 { lab=VLX}
N 700 14935 835 14935 { lab=Vout}
N 835 14935 985 14935 { lab=Vout}
N 985 14935 1145 14935 { lab=Vout}
N 1145 14935 1305 14935 { lab=Vout}
N 740 14905 740 14980 { lab=Vg}
N 740 14980 875 14980 { lab=Vg}
N 875 14905 875 14980 { lab=Vg}
N 875 14980 1030 14980 { lab=Vg}
N 1345 14905 1345 14980 { lab=Vg}
N 1030 14980 1345 14980 { lab=Vg}
N 1025 14905 1025 14980 { lab=Vg}
N 1185 14905 1185 14980 { lab=Vg}
N 700 14875 700 14905 { lab=VLX}
N 835 14875 835 14905 { lab=VLX}
N 985 14875 985 14905 { lab=VLX}
N 1145 14875 1145 14905 { lab=VLX}
N 1305 14875 1305 14905 { lab=VLX}
N 1440 14875 1575 14875 { lab=VLX}
N 1575 14875 1725 14875 { lab=VLX}
N 1725 14875 1885 14875 { lab=VLX}
N 1885 14875 2045 14875 { lab=VLX}
N 1440 14935 1575 14935 { lab=Vout}
N 1575 14935 1725 14935 { lab=Vout}
N 1725 14935 1885 14935 { lab=Vout}
N 1885 14935 2045 14935 { lab=Vout}
N 1480 14905 1480 14980 { lab=Vg}
N 1480 14980 1615 14980 { lab=Vg}
N 1615 14905 1615 14980 { lab=Vg}
N 1615 14980 1770 14980 { lab=Vg}
N 2085 14905 2085 14980 { lab=Vg}
N 1770 14980 2085 14980 { lab=Vg}
N 1765 14905 1765 14980 { lab=Vg}
N 1925 14905 1925 14980 { lab=Vg}
N 1440 14875 1440 14905 { lab=VLX}
N 1575 14875 1575 14905 { lab=VLX}
N 1725 14875 1725 14905 { lab=VLX}
N 1885 14875 1885 14905 { lab=VLX}
N 2045 14875 2045 14905 { lab=VLX}
N 1305 14875 1440 14875 { lab=VLX}
N 1305 14935 1440 14935 { lab=Vout}
N 1345 14980 1480 14980 { lab=Vg}
N 2195 14875 2330 14875 { lab=VLX}
N 2330 14875 2480 14875 { lab=VLX}
N 2480 14875 2640 14875 { lab=VLX}
N 2640 14875 2800 14875 { lab=VLX}
N 2195 14935 2330 14935 { lab=Vout}
N 2330 14935 2480 14935 { lab=Vout}
N 2480 14935 2640 14935 { lab=Vout}
N 2640 14935 2800 14935 { lab=Vout}
N 2235 14905 2235 14980 { lab=Vg}
N 2235 14980 2370 14980 { lab=Vg}
N 2370 14905 2370 14980 { lab=Vg}
N 2370 14980 2525 14980 { lab=Vg}
N 2840 14905 2840 14980 { lab=Vg}
N 2525 14980 2840 14980 { lab=Vg}
N 2520 14905 2520 14980 { lab=Vg}
N 2680 14905 2680 14980 { lab=Vg}
N 2195 14875 2195 14905 { lab=VLX}
N 2330 14875 2330 14905 { lab=VLX}
N 2480 14875 2480 14905 { lab=VLX}
N 2640 14875 2640 14905 { lab=VLX}
N 2800 14875 2800 14905 { lab=VLX}
N 2935 14875 3070 14875 { lab=VLX}
N 3070 14875 3220 14875 { lab=VLX}
N 3220 14875 3380 14875 { lab=VLX}
N 3380 14875 3540 14875 { lab=VLX}
N 2935 14935 3070 14935 { lab=Vout}
N 3070 14935 3220 14935 { lab=Vout}
N 3220 14935 3380 14935 { lab=Vout}
N 3380 14935 3540 14935 { lab=Vout}
N 2975 14905 2975 14980 { lab=Vg}
N 2975 14980 3110 14980 { lab=Vg}
N 3110 14905 3110 14980 { lab=Vg}
N 3110 14980 3265 14980 { lab=Vg}
N 3580 14905 3580 14980 { lab=Vg}
N 3265 14980 3580 14980 { lab=Vg}
N 3260 14905 3260 14980 { lab=Vg}
N 3420 14905 3420 14980 { lab=Vg}
N 2935 14875 2935 14905 { lab=VLX}
N 3070 14875 3070 14905 { lab=VLX}
N 3220 14875 3220 14905 { lab=VLX}
N 3380 14875 3380 14905 { lab=VLX}
N 3540 14875 3540 14905 { lab=VLX}
N 2800 14875 2935 14875 { lab=VLX}
N 2800 14935 2935 14935 { lab=Vout}
N 2840 14980 2975 14980 { lab=Vg}
N 2045 14875 2195 14875 { lab=VLX}
N 2085 14980 2235 14980 { lab=Vg}
N 2045 14935 2195 14935 { lab=Vout}
N 700 15040 835 15040 { lab=VLX}
N 835 15040 985 15040 { lab=VLX}
N 985 15040 1145 15040 { lab=VLX}
N 1145 15040 1305 15040 { lab=VLX}
N 700 15100 835 15100 { lab=Vout}
N 835 15100 985 15100 { lab=Vout}
N 985 15100 1145 15100 { lab=Vout}
N 1145 15100 1305 15100 { lab=Vout}
N 740 15070 740 15145 { lab=Vg}
N 740 15145 875 15145 { lab=Vg}
N 875 15070 875 15145 { lab=Vg}
N 875 15145 1030 15145 { lab=Vg}
N 1345 15070 1345 15145 { lab=Vg}
N 1030 15145 1345 15145 { lab=Vg}
N 1025 15070 1025 15145 { lab=Vg}
N 1185 15070 1185 15145 { lab=Vg}
N 700 15040 700 15070 { lab=VLX}
N 835 15040 835 15070 { lab=VLX}
N 985 15040 985 15070 { lab=VLX}
N 1145 15040 1145 15070 { lab=VLX}
N 1305 15040 1305 15070 { lab=VLX}
N 1440 15040 1575 15040 { lab=VLX}
N 1575 15040 1725 15040 { lab=VLX}
N 1725 15040 1885 15040 { lab=VLX}
N 1885 15040 2045 15040 { lab=VLX}
N 1440 15100 1575 15100 { lab=Vout}
N 1575 15100 1725 15100 { lab=Vout}
N 1725 15100 1885 15100 { lab=Vout}
N 1885 15100 2045 15100 { lab=Vout}
N 1480 15070 1480 15145 { lab=Vg}
N 1480 15145 1615 15145 { lab=Vg}
N 1615 15070 1615 15145 { lab=Vg}
N 1615 15145 1770 15145 { lab=Vg}
N 2085 15070 2085 15145 { lab=Vg}
N 1770 15145 2085 15145 { lab=Vg}
N 1765 15070 1765 15145 { lab=Vg}
N 1925 15070 1925 15145 { lab=Vg}
N 1440 15040 1440 15070 { lab=VLX}
N 1575 15040 1575 15070 { lab=VLX}
N 1725 15040 1725 15070 { lab=VLX}
N 1885 15040 1885 15070 { lab=VLX}
N 2045 15040 2045 15070 { lab=VLX}
N 1305 15040 1440 15040 { lab=VLX}
N 1305 15100 1440 15100 { lab=Vout}
N 1345 15145 1480 15145 { lab=Vg}
N 2195 15040 2330 15040 { lab=VLX}
N 2330 15040 2480 15040 { lab=VLX}
N 2480 15040 2640 15040 { lab=VLX}
N 2640 15040 2800 15040 { lab=VLX}
N 2195 15100 2330 15100 { lab=Vout}
N 2330 15100 2480 15100 { lab=Vout}
N 2480 15100 2640 15100 { lab=Vout}
N 2640 15100 2800 15100 { lab=Vout}
N 2235 15070 2235 15145 { lab=Vg}
N 2235 15145 2370 15145 { lab=Vg}
N 2370 15070 2370 15145 { lab=Vg}
N 2370 15145 2525 15145 { lab=Vg}
N 2840 15070 2840 15145 { lab=Vg}
N 2525 15145 2840 15145 { lab=Vg}
N 2520 15070 2520 15145 { lab=Vg}
N 2680 15070 2680 15145 { lab=Vg}
N 2195 15040 2195 15070 { lab=VLX}
N 2330 15040 2330 15070 { lab=VLX}
N 2480 15040 2480 15070 { lab=VLX}
N 2640 15040 2640 15070 { lab=VLX}
N 2800 15040 2800 15070 { lab=VLX}
N 2935 15040 3070 15040 { lab=VLX}
N 3070 15040 3220 15040 { lab=VLX}
N 3220 15040 3380 15040 { lab=VLX}
N 3380 15040 3540 15040 { lab=VLX}
N 2935 15100 3070 15100 { lab=Vout}
N 3070 15100 3220 15100 { lab=Vout}
N 3220 15100 3380 15100 { lab=Vout}
N 3380 15100 3540 15100 { lab=Vout}
N 2975 15070 2975 15145 { lab=Vg}
N 2975 15145 3110 15145 { lab=Vg}
N 3110 15070 3110 15145 { lab=Vg}
N 3110 15145 3265 15145 { lab=Vg}
N 3580 15070 3580 15145 { lab=Vg}
N 3265 15145 3580 15145 { lab=Vg}
N 3260 15070 3260 15145 { lab=Vg}
N 3420 15070 3420 15145 { lab=Vg}
N 2935 15040 2935 15070 { lab=VLX}
N 3070 15040 3070 15070 { lab=VLX}
N 3220 15040 3220 15070 { lab=VLX}
N 3380 15040 3380 15070 { lab=VLX}
N 3540 15040 3540 15070 { lab=VLX}
N 2800 15040 2935 15040 { lab=VLX}
N 2800 15100 2935 15100 { lab=Vout}
N 2840 15145 2975 15145 { lab=Vg}
N 2045 15040 2195 15040 { lab=VLX}
N 2085 15145 2235 15145 { lab=Vg}
N 2045 15100 2195 15100 { lab=Vout}
N 3580 14980 3580 15070 { lab=Vg}
N 455 14875 700 14875 { lab=VLX}
N 450 15040 700 15040 { lab=VLX}
N 450 14875 450 15040 { lab=VLX}
N 450 14875 455 14875 { lab=VLX}
N 570 14935 700 14935 { lab=Vout}
N 570 14935 570 15145 { lab=Vout}
N 700 15225 835 15225 { lab=VLX}
N 835 15225 985 15225 { lab=VLX}
N 985 15225 1145 15225 { lab=VLX}
N 1145 15225 1305 15225 { lab=VLX}
N 700 15285 835 15285 { lab=Vout}
N 835 15285 985 15285 { lab=Vout}
N 985 15285 1145 15285 { lab=Vout}
N 1145 15285 1305 15285 { lab=Vout}
N 740 15255 740 15330 { lab=Vg}
N 740 15330 875 15330 { lab=Vg}
N 875 15255 875 15330 { lab=Vg}
N 875 15330 1030 15330 { lab=Vg}
N 1345 15255 1345 15330 { lab=Vg}
N 1030 15330 1345 15330 { lab=Vg}
N 1025 15255 1025 15330 { lab=Vg}
N 1185 15255 1185 15330 { lab=Vg}
N 700 15225 700 15255 { lab=VLX}
N 835 15225 835 15255 { lab=VLX}
N 985 15225 985 15255 { lab=VLX}
N 1145 15225 1145 15255 { lab=VLX}
N 1305 15225 1305 15255 { lab=VLX}
N 1440 15225 1575 15225 { lab=VLX}
N 1575 15225 1725 15225 { lab=VLX}
N 1725 15225 1885 15225 { lab=VLX}
N 1885 15225 2045 15225 { lab=VLX}
N 1440 15285 1575 15285 { lab=Vout}
N 1575 15285 1725 15285 { lab=Vout}
N 1725 15285 1885 15285 { lab=Vout}
N 1885 15285 2045 15285 { lab=Vout}
N 1480 15255 1480 15330 { lab=Vg}
N 1480 15330 1615 15330 { lab=Vg}
N 1615 15255 1615 15330 { lab=Vg}
N 1615 15330 1770 15330 { lab=Vg}
N 2085 15255 2085 15330 { lab=Vg}
N 1770 15330 2085 15330 { lab=Vg}
N 1765 15255 1765 15330 { lab=Vg}
N 1925 15255 1925 15330 { lab=Vg}
N 1440 15225 1440 15255 { lab=VLX}
N 1575 15225 1575 15255 { lab=VLX}
N 1725 15225 1725 15255 { lab=VLX}
N 1885 15225 1885 15255 { lab=VLX}
N 2045 15225 2045 15255 { lab=VLX}
N 1305 15225 1440 15225 { lab=VLX}
N 1305 15285 1440 15285 { lab=Vout}
N 1345 15330 1480 15330 { lab=Vg}
N 2195 15225 2330 15225 { lab=VLX}
N 2330 15225 2480 15225 { lab=VLX}
N 2480 15225 2640 15225 { lab=VLX}
N 2640 15225 2800 15225 { lab=VLX}
N 2195 15285 2330 15285 { lab=Vout}
N 2330 15285 2480 15285 { lab=Vout}
N 2480 15285 2640 15285 { lab=Vout}
N 2640 15285 2800 15285 { lab=Vout}
N 2235 15255 2235 15330 { lab=Vg}
N 2235 15330 2370 15330 { lab=Vg}
N 2370 15255 2370 15330 { lab=Vg}
N 2370 15330 2525 15330 { lab=Vg}
N 2840 15255 2840 15330 { lab=Vg}
N 2525 15330 2840 15330 { lab=Vg}
N 2520 15255 2520 15330 { lab=Vg}
N 2680 15255 2680 15330 { lab=Vg}
N 2195 15225 2195 15255 { lab=VLX}
N 2330 15225 2330 15255 { lab=VLX}
N 2480 15225 2480 15255 { lab=VLX}
N 2640 15225 2640 15255 { lab=VLX}
N 2800 15225 2800 15255 { lab=VLX}
N 2935 15225 3070 15225 { lab=VLX}
N 3070 15225 3220 15225 { lab=VLX}
N 3220 15225 3380 15225 { lab=VLX}
N 3380 15225 3540 15225 { lab=VLX}
N 2935 15285 3070 15285 { lab=Vout}
N 3070 15285 3220 15285 { lab=Vout}
N 3220 15285 3380 15285 { lab=Vout}
N 3380 15285 3540 15285 { lab=Vout}
N 2975 15255 2975 15330 { lab=Vg}
N 2975 15330 3110 15330 { lab=Vg}
N 3110 15255 3110 15330 { lab=Vg}
N 3110 15330 3265 15330 { lab=Vg}
N 3580 15255 3580 15330 { lab=Vg}
N 3265 15330 3580 15330 { lab=Vg}
N 3260 15255 3260 15330 { lab=Vg}
N 3420 15255 3420 15330 { lab=Vg}
N 2935 15225 2935 15255 { lab=VLX}
N 3070 15225 3070 15255 { lab=VLX}
N 3220 15225 3220 15255 { lab=VLX}
N 3380 15225 3380 15255 { lab=VLX}
N 3540 15225 3540 15255 { lab=VLX}
N 2800 15225 2935 15225 { lab=VLX}
N 2800 15285 2935 15285 { lab=Vout}
N 2840 15330 2975 15330 { lab=Vg}
N 2045 15225 2195 15225 { lab=VLX}
N 2085 15330 2235 15330 { lab=Vg}
N 2045 15285 2195 15285 { lab=Vout}
N 700 15390 835 15390 { lab=VLX}
N 835 15390 985 15390 { lab=VLX}
N 985 15390 1145 15390 { lab=VLX}
N 1145 15390 1305 15390 { lab=VLX}
N 700 15450 835 15450 { lab=Vout}
N 835 15450 985 15450 { lab=Vout}
N 985 15450 1145 15450 { lab=Vout}
N 1145 15450 1305 15450 { lab=Vout}
N 740 15420 740 15495 { lab=Vg}
N 740 15495 875 15495 { lab=Vg}
N 875 15420 875 15495 { lab=Vg}
N 875 15495 1030 15495 { lab=Vg}
N 1345 15420 1345 15495 { lab=Vg}
N 1030 15495 1345 15495 { lab=Vg}
N 1025 15420 1025 15495 { lab=Vg}
N 1185 15420 1185 15495 { lab=Vg}
N 700 15390 700 15420 { lab=VLX}
N 835 15390 835 15420 { lab=VLX}
N 985 15390 985 15420 { lab=VLX}
N 1145 15390 1145 15420 { lab=VLX}
N 1305 15390 1305 15420 { lab=VLX}
N 1440 15390 1575 15390 { lab=VLX}
N 1575 15390 1725 15390 { lab=VLX}
N 1725 15390 1885 15390 { lab=VLX}
N 1885 15390 2045 15390 { lab=VLX}
N 1440 15450 1575 15450 { lab=Vout}
N 1575 15450 1725 15450 { lab=Vout}
N 1725 15450 1885 15450 { lab=Vout}
N 1885 15450 2045 15450 { lab=Vout}
N 1480 15420 1480 15495 { lab=Vg}
N 1480 15495 1615 15495 { lab=Vg}
N 1615 15420 1615 15495 { lab=Vg}
N 1615 15495 1770 15495 { lab=Vg}
N 2085 15420 2085 15495 { lab=Vg}
N 1770 15495 2085 15495 { lab=Vg}
N 1765 15420 1765 15495 { lab=Vg}
N 1925 15420 1925 15495 { lab=Vg}
N 1440 15390 1440 15420 { lab=VLX}
N 1575 15390 1575 15420 { lab=VLX}
N 1725 15390 1725 15420 { lab=VLX}
N 1885 15390 1885 15420 { lab=VLX}
N 2045 15390 2045 15420 { lab=VLX}
N 1305 15390 1440 15390 { lab=VLX}
N 1305 15450 1440 15450 { lab=Vout}
N 1345 15495 1480 15495 { lab=Vg}
N 2195 15390 2330 15390 { lab=VLX}
N 2330 15390 2480 15390 { lab=VLX}
N 2480 15390 2640 15390 { lab=VLX}
N 2640 15390 2800 15390 { lab=VLX}
N 2195 15450 2330 15450 { lab=Vout}
N 2330 15450 2480 15450 { lab=Vout}
N 2480 15450 2640 15450 { lab=Vout}
N 2640 15450 2800 15450 { lab=Vout}
N 2235 15420 2235 15495 { lab=Vg}
N 2235 15495 2370 15495 { lab=Vg}
N 2370 15420 2370 15495 { lab=Vg}
N 2370 15495 2525 15495 { lab=Vg}
N 2840 15420 2840 15495 { lab=Vg}
N 2525 15495 2840 15495 { lab=Vg}
N 2520 15420 2520 15495 { lab=Vg}
N 2680 15420 2680 15495 { lab=Vg}
N 2195 15390 2195 15420 { lab=VLX}
N 2330 15390 2330 15420 { lab=VLX}
N 2480 15390 2480 15420 { lab=VLX}
N 2640 15390 2640 15420 { lab=VLX}
N 2800 15390 2800 15420 { lab=VLX}
N 2935 15390 3070 15390 { lab=VLX}
N 3070 15390 3220 15390 { lab=VLX}
N 3220 15390 3380 15390 { lab=VLX}
N 3380 15390 3540 15390 { lab=VLX}
N 2935 15450 3070 15450 { lab=Vout}
N 3070 15450 3220 15450 { lab=Vout}
N 3220 15450 3380 15450 { lab=Vout}
N 3380 15450 3540 15450 { lab=Vout}
N 2975 15420 2975 15495 { lab=Vg}
N 2975 15495 3110 15495 { lab=Vg}
N 3110 15420 3110 15495 { lab=Vg}
N 3110 15495 3265 15495 { lab=Vg}
N 3580 15420 3580 15495 { lab=Vg}
N 3265 15495 3580 15495 { lab=Vg}
N 3260 15420 3260 15495 { lab=Vg}
N 3420 15420 3420 15495 { lab=Vg}
N 2935 15390 2935 15420 { lab=VLX}
N 3070 15390 3070 15420 { lab=VLX}
N 3220 15390 3220 15420 { lab=VLX}
N 3380 15390 3380 15420 { lab=VLX}
N 3540 15390 3540 15420 { lab=VLX}
N 2800 15390 2935 15390 { lab=VLX}
N 2800 15450 2935 15450 { lab=Vout}
N 2840 15495 2975 15495 { lab=Vg}
N 2045 15390 2195 15390 { lab=VLX}
N 2085 15495 2235 15495 { lab=Vg}
N 2045 15450 2195 15450 { lab=Vout}
N 3580 15330 3580 15420 { lab=Vg}
N 455 15225 700 15225 { lab=VLX}
N 450 15390 700 15390 { lab=VLX}
N 450 15225 450 15390 { lab=VLX}
N 450 15225 455 15225 { lab=VLX}
N 570 15285 700 15285 { lab=Vout}
N 450 15040 450 15230 { lab=VLX}
N 570 15140 570 15290 { lab=Vout}
N 3580 15140 3580 15260 { lab=Vg}
N 3580 14750 3580 14910 { lab=Vg}
N 570 14750 570 14940 { lab=Vout}
N 450 14650 450 14880 { lab=VLX}
N 410 -2500 410 -2465 { lab=VLX}
N 470 -2360 500 -2360 { lab=Vout}
N 3510 -2400 3545 -2400 { lab=Vg}
N 570 15450 700 15450 { lab=Vout}
N 570 15100 700 15100 { lab=Vout}
N 570 14710 700 14710 { lab=Vout}
N 570 14360 700 14360 { lab=Vout}
N 570 14040 700 14040 { lab=Vout}
N 570 13690 700 13690 { lab=Vout}
N 570 13290 700 13290 { lab=Vout}
N 570 12940 700 12940 { lab=Vout}
N 570 12620 700 12620 { lab=Vout}
N 570 12270 700 12270 { lab=Vout}
N 570 11850 700 11850 { lab=Vout}
N 570 11500 700 11500 { lab=Vout}
N 570 11180 700 11180 { lab=Vout}
N 570 10830 700 10830 { lab=Vout}
N 570 10430 700 10430 { lab=Vout}
N 570 10080 700 10080 { lab=Vout}
N 570 9760 700 9760 { lab=Vout}
N 570 9410 700 9410 { lab=Vout}
N 500 -1220 630 -1220 { lab=Vout}
N 570 15285 570 15450 { lab=Vout}
N 520 8880 650 8880 { lab=Vout}
N 520 8530 650 8530 { lab=Vout}
N 520 8210 650 8210 { lab=Vout}
N 520 7860 650 7860 { lab=Vout}
N 520 7460 650 7460 { lab=Vout}
N 520 7110 650 7110 { lab=Vout}
N 520 6790 650 6790 { lab=Vout}
N 520 6440 650 6440 { lab=Vout}
N 520 6020 650 6020 { lab=Vout}
N 520 5670 650 5670 { lab=Vout}
N 520 5350 650 5350 { lab=Vout}
N 520 5000 650 5000 { lab=Vout}
N 520 4600 650 4600 { lab=Vout}
N 520 4435 650 4435 { lab=Vout}
N 520 4250 650 4250 { lab=Vout}
N 520 4085 650 4085 { lab=Vout}
N 520 3930 650 3930 { lab=Vout}
N 520 3765 650 3765 { lab=Vout}
N 520 3580 650 3580 { lab=Vout}
N 520 3415 650 3415 { lab=Vout}
N 500 3060 630 3060 { lab=Vout}
N 500 2895 630 2895 { lab=Vout}
N 500 2710 630 2710 { lab=Vout}
N 500 2545 630 2545 { lab=Vout}
N 500 2390 630 2390 { lab=Vout}
N 500 2040 630 2040 { lab=Vout}
N 500 1640 630 1640 { lab=Vout}
N 500 1475 630 1475 { lab=Vout}
N 500 1290 630 1290 { lab=Vout}
N 500 970 630 970 { lab=Vout}
N 500 620 630 620 { lab=Vout}
N 500 200 630 200 { lab=Vout}
N 500 -150 630 -150 { lab=Vout}
N 500 -315 630 -315 { lab=Vout}
N 500 -470 630 -470 { lab=Vout}
N 500 -635 630 -635 { lab=Vout}
N 500 -820 630 -820 { lab=Vout}
N 500 -985 630 -985 { lab=Vout}
N 500 -1385 630 -1385 { lab=Vout}
N 500 -1570 630 -1570 { lab=Vout}
N 500 -1735 630 -1735 { lab=Vout}
N 500 -1890 630 -1890 { lab=Vout}
N 500 -2055 630 -2055 { lab=Vout}
N 500 -2240 630 -2240 { lab=Vout}
N 500 -2240 500 -2200 { lab=Vout}
N 500 -2360 500 -2235 { lab=Vout}
N 3510 -1770 3510 -1765 { lab=Vg}
N 3510 -360 3510 -335 { lab=Vg}
N 3510 1055 3510 1115 { lab=Vg}
N 3510 2435 3510 2515 { lab=Vg}
N 3530 4035 3530 4075 { lab=Vg}
N 3530 5440 3530 5550 { lab=Vg}
N 3530 6830 3530 6990 { lab=Vg}
N 3530 8250 3530 8415 { lab=Vg}
N 3530 8920 3530 8935 { lab=Vg}
N 3580 9850 3580 9910 { lab=Vg}
N 3580 11220 3580 11380 { lab=Vg}
N 3580 12660 3580 12825 { lab=Vg}
N 3580 14085 3580 14245 { lab=Vg}
N 500 -2405 500 -2360 { lab=Vout}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -2435 0 1 {name=M1
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -2435 0 1 {name=M2
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -2435 0 1 {name=M3
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -2435 0 1 {name=M4
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -2435 0 1 {name=M5
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -2435 0 1 {name=M6
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -2435 0 1 {name=M7
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -2435 0 1 {name=M8
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -2435 0 1 {name=M9
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -2435 0 1 {name=M10
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -2435 0 1 {name=M11
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -2435 0 1 {name=M12
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -2435 0 1 {name=M13
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -2435 0 1 {name=M14
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -2435 0 1 {name=M15
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -2435 0 1 {name=M16
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -2435 0 1 {name=M17
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -2435 0 1 {name=M18
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -2435 0 1 {name=M19
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -2435 0 1 {name=M20
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -2270 0 1 {name=M21
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -2270 0 1 {name=M22
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -2270 0 1 {name=M23
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -2270 0 1 {name=M24
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -2270 0 1 {name=M25
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -2270 0 1 {name=M26
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -2270 0 1 {name=M27
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -2270 0 1 {name=M28
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -2270 0 1 {name=M29
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -2270 0 1 {name=M30
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -2270 0 1 {name=M31
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -2270 0 1 {name=M32
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -2270 0 1 {name=M33
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -2270 0 1 {name=M34
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -2270 0 1 {name=M35
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -2270 0 1 {name=M36
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -2270 0 1 {name=M37
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -2270 0 1 {name=M38
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -2270 0 1 {name=M39
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -2270 0 1 {name=M40
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -2085 0 1 {name=M41
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -2085 0 1 {name=M42
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -2085 0 1 {name=M43
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -2085 0 1 {name=M44
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -2085 0 1 {name=M45
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -2085 0 1 {name=M46
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -2085 0 1 {name=M47
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -2085 0 1 {name=M48
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -2085 0 1 {name=M49
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -2085 0 1 {name=M50
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -2085 0 1 {name=M51
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -2085 0 1 {name=M52
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -2085 0 1 {name=M53
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -2085 0 1 {name=M54
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -2085 0 1 {name=M55
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -2085 0 1 {name=M56
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -2085 0 1 {name=M57
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -2085 0 1 {name=M58
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -2085 0 1 {name=M59
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -2085 0 1 {name=M60
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1920 0 1 {name=M61
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1920 0 1 {name=M62
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1920 0 1 {name=M63
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1920 0 1 {name=M64
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1920 0 1 {name=M65
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1920 0 1 {name=M66
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1920 0 1 {name=M67
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1920 0 1 {name=M68
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1920 0 1 {name=M69
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1920 0 1 {name=M70
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1920 0 1 {name=M71
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1920 0 1 {name=M72
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1920 0 1 {name=M73
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1920 0 1 {name=M74
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1920 0 1 {name=M75
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1920 0 1 {name=M76
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1920 0 1 {name=M77
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1920 0 1 {name=M78
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1920 0 1 {name=M79
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1920 0 1 {name=M80
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1765 0 1 {name=M81
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1765 0 1 {name=M82
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1765 0 1 {name=M83
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1765 0 1 {name=M84
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1765 0 1 {name=M85
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1765 0 1 {name=M86
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1765 0 1 {name=M87
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1765 0 1 {name=M88
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1765 0 1 {name=M89
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1765 0 1 {name=M90
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1765 0 1 {name=M91
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1765 0 1 {name=M92
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1765 0 1 {name=M93
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1765 0 1 {name=M94
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1765 0 1 {name=M95
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1765 0 1 {name=M96
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1765 0 1 {name=M97
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1765 0 1 {name=M98
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1765 0 1 {name=M99
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1765 0 1 {name=M100
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1600 0 1 {name=M101
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1600 0 1 {name=M102
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1600 0 1 {name=M103
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1600 0 1 {name=M104
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1600 0 1 {name=M105
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1600 0 1 {name=M106
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1600 0 1 {name=M107
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1600 0 1 {name=M108
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1600 0 1 {name=M109
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1600 0 1 {name=M110
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1600 0 1 {name=M111
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1600 0 1 {name=M112
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1600 0 1 {name=M113
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1600 0 1 {name=M114
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1600 0 1 {name=M115
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1600 0 1 {name=M116
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1600 0 1 {name=M117
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1600 0 1 {name=M118
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1600 0 1 {name=M119
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1600 0 1 {name=M120
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1415 0 1 {name=M121
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1415 0 1 {name=M122
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1415 0 1 {name=M123
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1415 0 1 {name=M124
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1415 0 1 {name=M125
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1415 0 1 {name=M126
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1415 0 1 {name=M127
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1415 0 1 {name=M128
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1415 0 1 {name=M129
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1415 0 1 {name=M130
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1415 0 1 {name=M131
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1415 0 1 {name=M132
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1415 0 1 {name=M133
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1415 0 1 {name=M134
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1415 0 1 {name=M135
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1415 0 1 {name=M136
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1415 0 1 {name=M137
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1415 0 1 {name=M138
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1415 0 1 {name=M139
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1415 0 1 {name=M140
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1250 0 1 {name=M141
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1250 0 1 {name=M142
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1250 0 1 {name=M143
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1250 0 1 {name=M144
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1250 0 1 {name=M145
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1250 0 1 {name=M146
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1250 0 1 {name=M147
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1250 0 1 {name=M148
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1250 0 1 {name=M149
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1250 0 1 {name=M150
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1250 0 1 {name=M151
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1250 0 1 {name=M152
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1250 0 1 {name=M153
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1250 0 1 {name=M154
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1250 0 1 {name=M155
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1250 0 1 {name=M156
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1250 0 1 {name=M157
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1250 0 1 {name=M158
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1250 0 1 {name=M159
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1250 0 1 {name=M160
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -1015 0 1 {name=M161
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -1015 0 1 {name=M162
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -1015 0 1 {name=M163
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -1015 0 1 {name=M164
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -1015 0 1 {name=M165
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -1015 0 1 {name=M166
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -1015 0 1 {name=M167
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -1015 0 1 {name=M168
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -1015 0 1 {name=M169
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -1015 0 1 {name=M170
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -1015 0 1 {name=M171
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -1015 0 1 {name=M172
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -1015 0 1 {name=M173
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -1015 0 1 {name=M174
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -1015 0 1 {name=M175
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -1015 0 1 {name=M176
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -1015 0 1 {name=M177
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -1015 0 1 {name=M178
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -1015 0 1 {name=M179
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -1015 0 1 {name=M180
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -850 0 1 {name=M181
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -850 0 1 {name=M182
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -850 0 1 {name=M183
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -850 0 1 {name=M184
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -850 0 1 {name=M185
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -850 0 1 {name=M186
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -850 0 1 {name=M187
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -850 0 1 {name=M188
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -850 0 1 {name=M189
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -850 0 1 {name=M190
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -850 0 1 {name=M191
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -850 0 1 {name=M192
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -850 0 1 {name=M193
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -850 0 1 {name=M194
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -850 0 1 {name=M195
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -850 0 1 {name=M196
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -850 0 1 {name=M197
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -850 0 1 {name=M198
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -850 0 1 {name=M199
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -850 0 1 {name=M200
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -665 0 1 {name=M201
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -665 0 1 {name=M202
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -665 0 1 {name=M203
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -665 0 1 {name=M204
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -665 0 1 {name=M205
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -665 0 1 {name=M206
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -665 0 1 {name=M207
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -665 0 1 {name=M208
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1835 -665 0 1 {name=M209
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1995 -665 0 1 {name=M210
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2145 -665 0 1 {name=M211
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2280 -665 0 1 {name=M212
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2430 -665 0 1 {name=M213
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2590 -665 0 1 {name=M214
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2750 -665 0 1 {name=M215
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2885 -665 0 1 {name=M216
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3020 -665 0 1 {name=M217
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3170 -665 0 1 {name=M218
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3330 -665 0 1 {name=M219
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 3490 -665 0 1 {name=M220
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 650 -500 0 1 {name=M221
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 785 -500 0 1 {name=M222
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 935 -500 0 1 {name=M223
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1095 -500 0 1 {name=M224
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1255 -500 0 1 {name=M225
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1390 -500 0 1 {name=M226
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1525 -500 0 1 {name=M227
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1675 -500 0 1 {name=M228
L=0.35
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
