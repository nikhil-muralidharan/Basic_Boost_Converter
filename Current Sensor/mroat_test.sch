v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {mroat.sym} 90 -30 0 0 {name=X1}
