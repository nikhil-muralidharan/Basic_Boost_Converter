** sch_path: Current Sensor/untitled-6.sch
**.subckt untitled-6
**.ends
.end
